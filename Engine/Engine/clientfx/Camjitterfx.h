camjitterfx.h