dynalightfx.h