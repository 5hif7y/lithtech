automessage.h