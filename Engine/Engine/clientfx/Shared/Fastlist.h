fastlist.h