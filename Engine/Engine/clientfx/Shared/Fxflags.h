fxflags.h