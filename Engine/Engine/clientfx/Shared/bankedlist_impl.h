bankedlist_impl.h