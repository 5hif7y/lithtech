basefx.h