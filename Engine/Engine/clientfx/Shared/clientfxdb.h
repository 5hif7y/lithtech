clientfxdb.h