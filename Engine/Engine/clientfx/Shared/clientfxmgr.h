clientfxmgr.h