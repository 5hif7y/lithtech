commonutilities.h