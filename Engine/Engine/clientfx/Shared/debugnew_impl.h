debugnew_impl.h