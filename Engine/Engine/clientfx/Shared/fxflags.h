FxFlags.h