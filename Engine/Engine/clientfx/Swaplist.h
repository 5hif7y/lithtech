swaplist.h