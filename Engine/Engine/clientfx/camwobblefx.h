camwobblefx.h