FlareSpriteFX.h