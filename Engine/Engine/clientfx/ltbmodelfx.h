ltbmodelfx.h