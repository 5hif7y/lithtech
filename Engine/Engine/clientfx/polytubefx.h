polytubefx.h