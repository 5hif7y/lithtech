strmctl.h