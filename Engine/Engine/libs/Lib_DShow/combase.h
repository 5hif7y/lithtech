combase.h