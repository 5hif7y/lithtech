cprop.h