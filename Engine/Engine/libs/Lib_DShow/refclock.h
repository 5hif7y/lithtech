refclock.h