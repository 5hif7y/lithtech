vtrans.h