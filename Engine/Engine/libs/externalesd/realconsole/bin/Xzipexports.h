xzipexports.h