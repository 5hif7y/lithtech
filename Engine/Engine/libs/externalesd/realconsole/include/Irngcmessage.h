irngcmessage.h