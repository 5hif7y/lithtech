rngc.h