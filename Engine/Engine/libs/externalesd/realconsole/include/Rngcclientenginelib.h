rngcclientenginelib.h