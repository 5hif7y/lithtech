rngclib.h