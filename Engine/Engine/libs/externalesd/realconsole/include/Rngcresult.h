rngcresult.h