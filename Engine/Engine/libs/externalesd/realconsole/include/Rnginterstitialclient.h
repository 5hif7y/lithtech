rnginterstitialclient.h