irngcclientengine.h