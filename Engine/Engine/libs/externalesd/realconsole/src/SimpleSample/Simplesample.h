simplesample.h