rmaaconf.h