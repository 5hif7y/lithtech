rmaallow.h