rmaasm.h