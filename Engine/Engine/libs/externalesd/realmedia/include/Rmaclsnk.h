rmaclsnk.h