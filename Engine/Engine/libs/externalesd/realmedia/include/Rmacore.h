rmacore.h