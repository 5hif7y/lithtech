rmaencod.h