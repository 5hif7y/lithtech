rmafiles.h