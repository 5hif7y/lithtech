rmagroup.h