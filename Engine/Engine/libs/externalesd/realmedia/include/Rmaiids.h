rmaiids.h