rmapends.h