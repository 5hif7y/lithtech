rmapsink.h