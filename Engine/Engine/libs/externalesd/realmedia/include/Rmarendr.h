rmarendr.h