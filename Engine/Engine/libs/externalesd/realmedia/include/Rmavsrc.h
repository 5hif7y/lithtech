rmavsrc.h