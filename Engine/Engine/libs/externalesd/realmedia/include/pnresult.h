pnresult.h