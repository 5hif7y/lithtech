pnwintyp.h