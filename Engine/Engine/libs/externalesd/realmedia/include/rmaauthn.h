rmaauthn.h