rmacfg.h