rmadb.h