rmaerror.h