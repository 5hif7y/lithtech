rmaformt.h