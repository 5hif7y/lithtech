rmalvtxt.h