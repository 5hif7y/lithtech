rmaphook.h