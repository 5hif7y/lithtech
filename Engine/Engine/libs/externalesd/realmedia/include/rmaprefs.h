rmaprefs.h