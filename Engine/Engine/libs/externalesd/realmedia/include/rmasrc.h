rmasrc.h