rmavalue.h