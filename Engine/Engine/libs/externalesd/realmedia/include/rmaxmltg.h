rmaxmltg.h