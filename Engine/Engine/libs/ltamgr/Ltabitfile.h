ltabitfile.h