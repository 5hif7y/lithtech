ltafilebuffer.h