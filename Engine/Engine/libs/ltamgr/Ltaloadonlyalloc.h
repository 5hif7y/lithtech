ltaloadonlyalloc.h