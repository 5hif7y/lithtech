ltanodereader.h