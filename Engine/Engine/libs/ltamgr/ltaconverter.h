ltaconverter.h