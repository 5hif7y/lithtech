ltahuffmantree.h