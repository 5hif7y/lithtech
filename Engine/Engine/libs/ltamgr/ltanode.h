ltanode.h