ltanodewriter.h