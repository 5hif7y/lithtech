ltaparseutils.h