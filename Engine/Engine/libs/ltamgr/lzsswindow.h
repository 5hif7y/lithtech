lzsswindow.h