generalheap.h