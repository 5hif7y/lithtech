ltmemheap.h