ltmemtrack.h