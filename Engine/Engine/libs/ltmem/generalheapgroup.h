generalheapgroup.h