rezmgr.h