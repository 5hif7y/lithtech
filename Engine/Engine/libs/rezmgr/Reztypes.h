reztypes.h