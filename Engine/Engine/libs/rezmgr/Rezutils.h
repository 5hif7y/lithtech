rezutils.h