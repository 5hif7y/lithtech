rezhash.h