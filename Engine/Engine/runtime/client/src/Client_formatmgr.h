client_formatmgr.h