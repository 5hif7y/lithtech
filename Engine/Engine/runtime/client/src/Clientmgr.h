clientmgr.h