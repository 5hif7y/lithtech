clientshell.h