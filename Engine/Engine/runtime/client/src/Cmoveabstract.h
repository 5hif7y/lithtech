cmoveabstract.h