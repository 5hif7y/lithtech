ltinfo_impl.h