lttexturestring.h