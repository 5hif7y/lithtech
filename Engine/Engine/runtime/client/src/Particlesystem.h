particlesystem.h