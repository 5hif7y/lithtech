setupobject.h