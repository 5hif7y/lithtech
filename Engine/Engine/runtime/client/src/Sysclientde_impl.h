sysclientde_impl.h