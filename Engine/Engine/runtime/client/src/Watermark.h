watermark.h