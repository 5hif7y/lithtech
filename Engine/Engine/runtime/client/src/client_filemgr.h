client_filemgr.h