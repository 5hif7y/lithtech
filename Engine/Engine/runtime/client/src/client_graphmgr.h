client_graphmgr.h