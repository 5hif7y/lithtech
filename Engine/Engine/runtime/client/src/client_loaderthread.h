client_loaderthread.h