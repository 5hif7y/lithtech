client_ticks.h