clientexception.h