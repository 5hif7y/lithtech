customfontfilemgr.h