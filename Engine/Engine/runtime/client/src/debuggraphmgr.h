debuggraphmgr.h