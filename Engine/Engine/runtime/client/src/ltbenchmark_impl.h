ltbenchmark_impl.h