memorywatch.h