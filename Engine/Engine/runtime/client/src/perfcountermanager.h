perfcountermanager.h