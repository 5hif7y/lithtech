polygrid.h