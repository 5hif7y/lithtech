sprite.h