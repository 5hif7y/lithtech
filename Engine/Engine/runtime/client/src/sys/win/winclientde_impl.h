winclientde_impl.h