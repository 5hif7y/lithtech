winconsole_impl.h