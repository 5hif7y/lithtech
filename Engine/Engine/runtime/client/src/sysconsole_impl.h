sysconsole_impl.h