ltraudiohook.h