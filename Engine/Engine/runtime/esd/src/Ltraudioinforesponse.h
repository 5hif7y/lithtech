ltraudioinforesponse.h