ltraudioqueue.h