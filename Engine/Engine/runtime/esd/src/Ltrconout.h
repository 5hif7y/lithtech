ltrconout.h