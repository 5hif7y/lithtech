ltrealaudio_impl.h