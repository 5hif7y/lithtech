ltrealcore.h