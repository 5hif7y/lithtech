ltrvdef.h