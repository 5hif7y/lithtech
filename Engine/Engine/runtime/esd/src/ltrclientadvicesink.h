ltrclientadvicesink.h