ltrclientenginesetup.h