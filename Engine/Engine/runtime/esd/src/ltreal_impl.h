ltreal_impl.h