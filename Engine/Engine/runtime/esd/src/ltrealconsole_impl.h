ltrealconsole_impl.h