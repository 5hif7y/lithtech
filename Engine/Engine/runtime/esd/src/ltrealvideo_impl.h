ltrealvideo_impl.h