ltrmap.h