ltrvideooverlay.h