ltrvideosurface.h