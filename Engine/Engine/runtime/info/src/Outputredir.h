outputredir.h