de_memory.h