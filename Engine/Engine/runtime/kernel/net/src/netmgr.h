netmgr.h