libltkernel.h