sysinterface_helpers.h