dsys.h