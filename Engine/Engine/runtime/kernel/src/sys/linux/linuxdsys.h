linuxdsys.h