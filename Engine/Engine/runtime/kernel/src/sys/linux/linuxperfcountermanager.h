linuxperfcountermanager.h