interface_helpers.h