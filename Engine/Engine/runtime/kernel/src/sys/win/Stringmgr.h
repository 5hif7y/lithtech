stringmgr.h