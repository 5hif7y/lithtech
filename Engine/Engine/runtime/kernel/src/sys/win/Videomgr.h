videomgr.h