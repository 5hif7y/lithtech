binkvideomgrimpl.h