clientde_impl_sys.h