DDPerfCounterManager.h