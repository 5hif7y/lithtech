dsys_interface.h