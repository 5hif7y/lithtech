ltdirectmusic_impl.h