ltdirectmusicloader.h