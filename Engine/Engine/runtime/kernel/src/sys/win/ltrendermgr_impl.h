ltrendermgr_impl.h