streamsim.h