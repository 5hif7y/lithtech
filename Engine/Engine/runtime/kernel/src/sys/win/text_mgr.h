text_mgr.h