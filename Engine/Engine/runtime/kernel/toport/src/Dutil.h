dutil.h