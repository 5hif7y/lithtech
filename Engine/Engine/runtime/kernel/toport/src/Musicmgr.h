musicmgr.h