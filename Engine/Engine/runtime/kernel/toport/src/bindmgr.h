bindmgr.h