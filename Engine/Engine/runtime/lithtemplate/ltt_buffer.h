ltt_buffer.h