ltt_list_circular.h