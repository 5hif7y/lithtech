modelallocations.h