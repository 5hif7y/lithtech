clipline.h