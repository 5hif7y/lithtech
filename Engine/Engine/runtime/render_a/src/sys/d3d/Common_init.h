common_init.h