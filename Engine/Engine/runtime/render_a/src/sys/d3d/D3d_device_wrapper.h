d3d_device_wrapper.h