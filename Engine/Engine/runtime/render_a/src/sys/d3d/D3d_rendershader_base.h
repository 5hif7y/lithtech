d3d_rendershader_base.h