d3d_rendershader_gouraud.h