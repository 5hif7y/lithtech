d3d_rendershader_gouraud_fullbright.h