d3d_rendershader_lightmap.h