d3d_rendobj_spritearray.h