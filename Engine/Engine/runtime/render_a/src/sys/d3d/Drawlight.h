drawlight.h