drawworldmodel.h