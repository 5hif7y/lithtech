erendershader.h