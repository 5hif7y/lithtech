lteffectimpl.h