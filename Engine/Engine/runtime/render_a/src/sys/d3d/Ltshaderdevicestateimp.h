ltshaderdevicestateimp.h