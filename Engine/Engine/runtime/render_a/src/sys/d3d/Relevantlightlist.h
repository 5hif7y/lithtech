relevantlightlist.h