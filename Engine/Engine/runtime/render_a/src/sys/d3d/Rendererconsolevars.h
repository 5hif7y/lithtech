rendererconsolevars.h