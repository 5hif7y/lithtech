rendershadowlist.h