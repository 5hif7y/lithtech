renderstylemap.h