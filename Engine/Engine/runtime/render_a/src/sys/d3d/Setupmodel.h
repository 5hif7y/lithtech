setupmodel.h