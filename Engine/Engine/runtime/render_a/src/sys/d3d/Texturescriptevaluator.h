texturescriptevaluator.h