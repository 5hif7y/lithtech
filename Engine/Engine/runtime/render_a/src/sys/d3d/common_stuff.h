common_stuff.h