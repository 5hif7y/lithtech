d3d_defs.h