d3d_draw.h