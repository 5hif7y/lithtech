d3d_renderblock.h