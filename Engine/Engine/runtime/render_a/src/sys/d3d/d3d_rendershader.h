d3d_rendershader.h