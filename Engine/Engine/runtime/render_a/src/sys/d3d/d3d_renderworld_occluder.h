d3d_renderworld_occluder.h