d3d_texture.h