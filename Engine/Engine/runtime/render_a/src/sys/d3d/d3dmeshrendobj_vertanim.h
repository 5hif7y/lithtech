d3dmeshrendobj_vertanim.h