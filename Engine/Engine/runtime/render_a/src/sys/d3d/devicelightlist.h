devicelightlist.h