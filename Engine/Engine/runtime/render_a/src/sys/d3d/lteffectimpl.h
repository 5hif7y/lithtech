LTEffectImpl.h