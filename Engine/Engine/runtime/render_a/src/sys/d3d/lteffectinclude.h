lteffectinclude.h