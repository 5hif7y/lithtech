lteffectshadermgr.h