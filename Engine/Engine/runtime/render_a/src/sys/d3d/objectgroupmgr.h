objectgroupmgr.h