polyclip.h