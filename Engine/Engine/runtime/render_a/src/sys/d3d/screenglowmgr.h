screenglowmgr.h