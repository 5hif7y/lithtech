setuptouchinglights.h