texturescriptinstance.h