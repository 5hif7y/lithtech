texturescriptmgr.h