texturescriptvarmgr.h