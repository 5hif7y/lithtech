d3dmodelshadowrenderer.h