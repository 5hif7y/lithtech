gendrawprim.h