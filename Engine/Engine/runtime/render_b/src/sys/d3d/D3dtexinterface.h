d3dtexinterface.h