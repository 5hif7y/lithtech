server_consolestate.h