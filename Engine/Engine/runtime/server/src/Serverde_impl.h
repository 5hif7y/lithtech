serverde_impl.h