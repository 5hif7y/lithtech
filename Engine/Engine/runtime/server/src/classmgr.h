classmgr.h