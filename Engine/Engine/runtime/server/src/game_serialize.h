game_serialize.h