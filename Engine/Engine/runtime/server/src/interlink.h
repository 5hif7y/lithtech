interlink.h