server_filemgr.h