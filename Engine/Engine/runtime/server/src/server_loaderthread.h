server_loaderthread.h