servermgr.h