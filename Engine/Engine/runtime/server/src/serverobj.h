serverobj.h