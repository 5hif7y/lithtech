smoveabstract.h