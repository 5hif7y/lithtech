ftbase.h