lightmap_planes.h