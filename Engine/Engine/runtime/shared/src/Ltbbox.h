ltbbox.h