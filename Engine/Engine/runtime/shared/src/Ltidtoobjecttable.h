ltidtoobjecttable.h