nexus.h