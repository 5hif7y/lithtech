shared_iltcommon.h