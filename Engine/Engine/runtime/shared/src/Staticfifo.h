staticfifo.h