varsetter.h