clienthack.h