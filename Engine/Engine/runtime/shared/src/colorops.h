colorops.h