conparse.h