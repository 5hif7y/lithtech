debuggeometry.h