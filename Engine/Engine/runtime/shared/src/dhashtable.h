dhashtable.h