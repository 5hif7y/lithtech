genericprop_setup.h