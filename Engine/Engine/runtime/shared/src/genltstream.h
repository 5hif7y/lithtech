genltstream.h