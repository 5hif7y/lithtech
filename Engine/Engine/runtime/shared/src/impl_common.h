impl_common.h