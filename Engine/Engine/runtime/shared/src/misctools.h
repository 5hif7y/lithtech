misctools.h