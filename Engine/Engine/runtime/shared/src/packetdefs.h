packetdefs.h