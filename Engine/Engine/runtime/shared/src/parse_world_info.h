parse_world_info.h