ratetracker.h