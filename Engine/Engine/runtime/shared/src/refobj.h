refobj.h