renderinfostruct.h