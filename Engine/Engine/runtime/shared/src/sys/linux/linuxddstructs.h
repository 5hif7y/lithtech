linuxddstructs.h