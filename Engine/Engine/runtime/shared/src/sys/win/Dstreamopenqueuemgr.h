dstreamopenqueuemgr.h