renderstruct.h