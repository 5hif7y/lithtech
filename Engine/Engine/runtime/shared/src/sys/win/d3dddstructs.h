d3dddstructs.h