winsync.h