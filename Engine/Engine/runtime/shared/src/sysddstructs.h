sysddstructs.h