soundbuffer.h