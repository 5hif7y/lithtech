soundinstance.h