cuicheck_impl.h