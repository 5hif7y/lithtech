cuiinterval_impl.h