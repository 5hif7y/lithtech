cuioption_impl.h