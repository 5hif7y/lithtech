cuipolystring_impl.h