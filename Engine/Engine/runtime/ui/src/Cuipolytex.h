cuipolytex.h