cuislider_impl.h