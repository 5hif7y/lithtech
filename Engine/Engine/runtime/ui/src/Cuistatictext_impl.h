cuistatictext_impl.h