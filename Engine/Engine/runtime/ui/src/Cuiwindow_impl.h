cuiwindow_impl.h