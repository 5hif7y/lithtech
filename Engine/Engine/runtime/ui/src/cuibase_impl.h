cuibase_impl.h