cuidebug.h