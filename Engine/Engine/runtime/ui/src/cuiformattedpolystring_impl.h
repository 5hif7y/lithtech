cuiformattedpolystring_impl.h