cuilist_impl.h