cuiprogress_impl.h