cuistaticimage_impl.h