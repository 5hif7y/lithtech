cuiwidgetmanager.h