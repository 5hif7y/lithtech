ftoutln.h