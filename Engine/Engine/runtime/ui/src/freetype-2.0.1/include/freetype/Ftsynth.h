ftsynth.h