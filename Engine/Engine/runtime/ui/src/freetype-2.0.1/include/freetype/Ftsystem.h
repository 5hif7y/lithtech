ftsystem.h