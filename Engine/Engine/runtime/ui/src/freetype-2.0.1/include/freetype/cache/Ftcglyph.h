ftcglyph.h