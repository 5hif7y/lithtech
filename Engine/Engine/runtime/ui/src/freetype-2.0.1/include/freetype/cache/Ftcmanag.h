ftcmanag.h