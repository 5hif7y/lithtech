ftcsbits.h