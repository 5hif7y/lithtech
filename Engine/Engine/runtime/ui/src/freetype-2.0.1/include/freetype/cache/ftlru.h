ftlru.h