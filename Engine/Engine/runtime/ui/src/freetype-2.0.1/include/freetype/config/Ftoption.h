ftoption.h