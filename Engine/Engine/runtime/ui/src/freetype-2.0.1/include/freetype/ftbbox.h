ftbbox.h