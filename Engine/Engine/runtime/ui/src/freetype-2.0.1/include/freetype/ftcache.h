ftcache.h