fterrors.h