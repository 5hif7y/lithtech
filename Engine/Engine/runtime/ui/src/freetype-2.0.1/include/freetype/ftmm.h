ftmm.h