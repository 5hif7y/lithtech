ftmodule.h