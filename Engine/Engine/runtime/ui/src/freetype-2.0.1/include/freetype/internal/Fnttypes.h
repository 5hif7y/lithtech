fnttypes.h