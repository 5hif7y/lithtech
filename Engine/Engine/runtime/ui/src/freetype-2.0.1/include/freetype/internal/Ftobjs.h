ftobjs.h