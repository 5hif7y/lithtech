ftstream.h