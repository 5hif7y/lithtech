t1errors.h