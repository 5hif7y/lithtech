ftcalc.h