ftdebug.h