ftdriver.h