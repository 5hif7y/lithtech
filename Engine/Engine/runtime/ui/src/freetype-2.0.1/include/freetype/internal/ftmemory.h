ftmemory.h