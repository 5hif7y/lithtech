t2errors.h