tterrors.h