tttypes.h