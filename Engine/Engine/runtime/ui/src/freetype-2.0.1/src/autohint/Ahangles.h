ahangles.h