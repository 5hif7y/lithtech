ahglobal.h