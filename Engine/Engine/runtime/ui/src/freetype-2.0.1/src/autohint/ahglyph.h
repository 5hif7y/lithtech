ahglyph.h