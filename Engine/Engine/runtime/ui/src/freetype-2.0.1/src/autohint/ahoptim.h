ahoptim.h