ahtypes.h