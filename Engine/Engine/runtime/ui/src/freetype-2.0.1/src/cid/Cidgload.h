cidgload.h