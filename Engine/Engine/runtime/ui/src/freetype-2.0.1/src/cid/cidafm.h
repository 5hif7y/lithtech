cidafm.h