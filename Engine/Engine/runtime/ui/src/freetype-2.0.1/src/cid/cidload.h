cidload.h