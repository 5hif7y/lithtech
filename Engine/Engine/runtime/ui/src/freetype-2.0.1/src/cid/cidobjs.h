cidobjs.h