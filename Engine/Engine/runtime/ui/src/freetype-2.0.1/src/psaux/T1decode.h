t1decode.h