ftraster.h