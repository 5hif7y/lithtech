ftrend1.h