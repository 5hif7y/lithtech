sfobjs.h