ttsbit.h