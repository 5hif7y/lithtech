ttcmap.h