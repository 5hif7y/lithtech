ftgrays.h