ftsmooth.h