ttgload.h