ttobjs.h