t1objs.h