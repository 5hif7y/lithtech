de_objects.h