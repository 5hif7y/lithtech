fullintersectline.h