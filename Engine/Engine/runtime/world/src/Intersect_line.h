intersect_line.h