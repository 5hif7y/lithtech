de_sprite.h