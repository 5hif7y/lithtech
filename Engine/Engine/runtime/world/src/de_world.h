de_world.h