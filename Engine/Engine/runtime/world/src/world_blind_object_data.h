world_blind_object_data.h