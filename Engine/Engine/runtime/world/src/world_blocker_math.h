world_blocker_math.h