world_client_bsp.h