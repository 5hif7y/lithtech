world_interface.h