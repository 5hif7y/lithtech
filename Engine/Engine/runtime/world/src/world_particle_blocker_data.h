world_particle_blocker_data.h