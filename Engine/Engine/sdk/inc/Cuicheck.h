cuicheck.h