cuipolystring.h