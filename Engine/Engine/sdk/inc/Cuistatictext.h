cuistatictext.h