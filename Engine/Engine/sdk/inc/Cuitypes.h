cuitypes.h