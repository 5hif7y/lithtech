cuiwidget.h