iaggregate.h