iltbaseclass.h