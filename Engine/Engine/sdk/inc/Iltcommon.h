iltcommon.h