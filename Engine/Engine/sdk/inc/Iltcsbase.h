iltcsbase.h