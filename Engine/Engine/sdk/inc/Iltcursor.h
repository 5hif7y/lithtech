iltcursor.h