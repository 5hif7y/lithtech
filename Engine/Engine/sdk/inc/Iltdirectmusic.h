iltdirectmusic.h