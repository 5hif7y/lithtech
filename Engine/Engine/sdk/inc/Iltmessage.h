iltmessage.h