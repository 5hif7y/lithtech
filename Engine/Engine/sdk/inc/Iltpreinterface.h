iltpreinterface.h