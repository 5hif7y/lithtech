iltrefcount.h