iltsoundmgr.h