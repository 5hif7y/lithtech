iltwidgetmanager.h