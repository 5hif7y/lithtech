libltdiagnostics.h