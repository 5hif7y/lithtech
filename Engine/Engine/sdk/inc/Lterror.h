lterror.h