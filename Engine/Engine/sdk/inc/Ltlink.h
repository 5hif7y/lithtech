ltlink.h