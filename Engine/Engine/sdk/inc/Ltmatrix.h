ltmatrix.h