ltobjref.h