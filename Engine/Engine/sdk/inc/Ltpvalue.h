ltpvalue.h