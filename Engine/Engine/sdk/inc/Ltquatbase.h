ltquatbase.h