ltrotation.h