ltserverobj.h