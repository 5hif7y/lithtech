cuibase.h