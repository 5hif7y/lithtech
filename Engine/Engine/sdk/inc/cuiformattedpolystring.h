cuiformattedpolystring.h