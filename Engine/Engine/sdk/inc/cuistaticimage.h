cuistaticimage.h