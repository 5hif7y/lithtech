iltrealvideo.h