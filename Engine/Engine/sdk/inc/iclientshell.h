iclientshell.h