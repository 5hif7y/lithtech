iltmodel.h