iltremovablestoragemgr.h