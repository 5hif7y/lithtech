iltrendermgr.h