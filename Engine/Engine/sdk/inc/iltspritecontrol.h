iltspritecontrol.h