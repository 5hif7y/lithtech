ilttexinterface.h