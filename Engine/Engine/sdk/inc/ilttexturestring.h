ilttexturestring.h