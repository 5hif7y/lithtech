iservershell.h