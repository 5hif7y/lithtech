iltdiagnosticinstanceinfo.h