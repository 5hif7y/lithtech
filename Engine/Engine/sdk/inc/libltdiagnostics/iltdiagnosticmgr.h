iltdiagnosticmgr.h