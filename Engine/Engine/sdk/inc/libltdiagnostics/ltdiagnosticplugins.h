ltdiagnosticplugins.h