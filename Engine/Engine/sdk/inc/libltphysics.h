libltphysics.h