ltanimtracker.h