ltbasedefs.h