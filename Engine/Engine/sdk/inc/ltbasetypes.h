ltbasetypes.h