ltbeziercurve.h