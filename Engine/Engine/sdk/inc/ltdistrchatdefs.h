ltdistrchatdefs.h