ltengineobjects.h