lteulerangles.h