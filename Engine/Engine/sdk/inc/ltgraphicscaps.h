ltgraphicscaps.h