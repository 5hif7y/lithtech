ltmodule.h