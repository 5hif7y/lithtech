ltplane.h