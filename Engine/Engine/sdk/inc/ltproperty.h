ltproperty.h