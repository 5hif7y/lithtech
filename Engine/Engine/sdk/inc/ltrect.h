ltrect.h