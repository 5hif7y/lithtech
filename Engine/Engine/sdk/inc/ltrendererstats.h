ltrendererstats.h