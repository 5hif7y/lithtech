ltvector.h