aabb_tree.h