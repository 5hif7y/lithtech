collision_data.h