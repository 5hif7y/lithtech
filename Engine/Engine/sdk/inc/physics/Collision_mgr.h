collision_mgr.h