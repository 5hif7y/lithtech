collision_stream.h