coordinate_frame.h