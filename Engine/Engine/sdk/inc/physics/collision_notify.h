collision_notify.h