collision_object.h