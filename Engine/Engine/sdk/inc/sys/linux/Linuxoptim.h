linuxoptim.h