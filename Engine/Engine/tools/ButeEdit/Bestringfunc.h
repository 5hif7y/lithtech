bestringfunc.h