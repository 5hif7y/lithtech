buteeditdoc.h