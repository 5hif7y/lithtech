modifybytedlg.h