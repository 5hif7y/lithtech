modifydlgbase.h