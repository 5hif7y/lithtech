modifyfloatdlg.h