modifyrectangledlg.h