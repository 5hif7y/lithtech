modifystringdlg.h