modifyvectordlg.h