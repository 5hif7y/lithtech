BEStringFunc.h