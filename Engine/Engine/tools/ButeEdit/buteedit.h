ButeEdit.h