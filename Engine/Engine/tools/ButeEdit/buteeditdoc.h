ButeEditDoc.h