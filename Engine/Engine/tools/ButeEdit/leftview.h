leftview.h