modifydoubledlg.h