ModifyFloatDlg.h