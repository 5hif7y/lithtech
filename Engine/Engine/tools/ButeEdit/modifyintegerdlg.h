modifyintegerdlg.h