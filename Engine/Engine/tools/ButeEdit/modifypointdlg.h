modifypointdlg.h