modifyrangedlg.h