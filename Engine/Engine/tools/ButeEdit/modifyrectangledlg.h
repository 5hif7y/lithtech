ModifyRectangleDlg.h