ModifyStringDlg.h