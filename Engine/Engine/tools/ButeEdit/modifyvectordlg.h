ModifyVectorDlg.h