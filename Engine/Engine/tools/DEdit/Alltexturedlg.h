alltexturedlg.h