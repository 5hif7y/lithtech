baserezdlg.h