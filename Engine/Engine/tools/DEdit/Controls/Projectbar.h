projectbar.h