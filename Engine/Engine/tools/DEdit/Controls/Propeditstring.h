propeditstring.h