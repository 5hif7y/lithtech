resizebar.h