classtree.h