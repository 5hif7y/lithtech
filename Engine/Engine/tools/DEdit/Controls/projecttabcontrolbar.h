ProjectTabControlBar.h