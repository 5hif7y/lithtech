PropEditString.h