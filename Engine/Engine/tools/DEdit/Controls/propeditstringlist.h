propeditstringlist.h