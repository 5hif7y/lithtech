alphafromcolordlg.h