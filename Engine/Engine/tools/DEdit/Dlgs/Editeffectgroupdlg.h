editeffectgroupdlg.h