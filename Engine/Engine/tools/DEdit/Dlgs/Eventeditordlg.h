eventeditordlg.h