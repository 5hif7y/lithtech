generateuniquenamesdlg.h