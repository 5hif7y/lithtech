lightattenuation.h