objectselfilterdlg.h