objecttrackerdlg.h