proppageoptionslighting.h