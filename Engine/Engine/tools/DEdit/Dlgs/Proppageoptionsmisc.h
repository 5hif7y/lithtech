proppageoptionsmisc.h