rotationedit.h