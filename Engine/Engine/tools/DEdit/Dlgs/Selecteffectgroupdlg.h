selecteffectgroupdlg.h