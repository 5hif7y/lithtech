solidalphadlg.h