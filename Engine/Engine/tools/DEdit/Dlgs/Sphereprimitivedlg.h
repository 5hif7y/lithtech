sphereprimitivedlg.h