spriteeditdlg.h