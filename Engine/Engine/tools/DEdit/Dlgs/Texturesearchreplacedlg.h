texturesearchreplacedlg.h