addobjectdlg.h