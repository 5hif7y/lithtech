AlphaFromColorDlg.h