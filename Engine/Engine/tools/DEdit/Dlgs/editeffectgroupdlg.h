EditEffectGroupDlg.h