EventEditorDlg.h