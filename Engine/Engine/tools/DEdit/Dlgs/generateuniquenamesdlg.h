GenerateUniqueNamesDlg.h