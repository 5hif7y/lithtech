ImportBumpMapDlg.h