levelerroroptionsdlg.h