LightAttenuation.h