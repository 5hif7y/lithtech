navigatorstoredlg.h