ObjectSelFilterDlg.h