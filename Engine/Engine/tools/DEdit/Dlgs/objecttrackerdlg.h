ObjectTrackerDlg.h