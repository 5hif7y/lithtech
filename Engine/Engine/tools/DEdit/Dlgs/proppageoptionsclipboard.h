proppageoptionsclipboard.h