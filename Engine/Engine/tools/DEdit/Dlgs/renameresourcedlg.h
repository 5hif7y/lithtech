renameresourcedlg.h