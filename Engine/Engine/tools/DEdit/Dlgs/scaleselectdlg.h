scaleselectdlg.h