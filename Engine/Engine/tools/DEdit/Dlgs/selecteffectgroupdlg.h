SelectEffectGroupDlg.h