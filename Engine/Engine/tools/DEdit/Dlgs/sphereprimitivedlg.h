SpherePrimitiveDlg.h