SpriteEditDlg.h