TextureSearchReplaceDlg.h