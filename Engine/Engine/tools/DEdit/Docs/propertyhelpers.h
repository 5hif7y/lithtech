propertyhelpers.h