exportobjfile.h