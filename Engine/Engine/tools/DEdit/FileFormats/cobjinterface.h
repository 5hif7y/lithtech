cobjinterface.h