coolbar.h