globalhotkeydb.h