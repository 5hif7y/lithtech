deditkeyaggregate.h