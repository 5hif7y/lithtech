maxkeyaggregate.h