DEditKeyAggregate.h