keydefaultaggregate.h