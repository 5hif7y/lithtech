MaxKeyAggregate.h