errordetector.h