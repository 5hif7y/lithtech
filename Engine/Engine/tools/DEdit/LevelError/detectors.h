Detectors.h