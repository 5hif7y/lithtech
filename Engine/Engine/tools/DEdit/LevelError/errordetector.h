ErrorDetector.h