levelerrordb.h