lightmapgenerator.h