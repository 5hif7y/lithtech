lightmapholder.h