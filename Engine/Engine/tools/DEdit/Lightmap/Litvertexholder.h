litvertexholder.h