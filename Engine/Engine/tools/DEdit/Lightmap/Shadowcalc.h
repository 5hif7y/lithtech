shadowcalc.h