surfacelmtexturemgr.h