boundingsphere.h