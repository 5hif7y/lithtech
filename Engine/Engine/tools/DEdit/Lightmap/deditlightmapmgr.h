deditlightmapmgr.h