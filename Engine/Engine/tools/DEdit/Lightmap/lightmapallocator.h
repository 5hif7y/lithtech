lightmapallocator.h