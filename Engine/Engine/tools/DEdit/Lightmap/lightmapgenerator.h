LightMapGenerator.h