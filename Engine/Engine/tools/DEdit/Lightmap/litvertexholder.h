LitVertexHolder.h