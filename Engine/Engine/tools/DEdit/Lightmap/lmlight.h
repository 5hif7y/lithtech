lmlight.h