lmsamplegen.h