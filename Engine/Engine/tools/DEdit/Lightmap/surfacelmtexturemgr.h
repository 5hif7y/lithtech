SurfaceLMTextureMgr.h