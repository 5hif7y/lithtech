cfgtbar.h