mdifloat.h