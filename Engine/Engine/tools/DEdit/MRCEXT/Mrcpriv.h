mrcpriv.h