mrcresrc.h