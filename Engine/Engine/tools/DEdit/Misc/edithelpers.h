edithelpers.h