EditorTransfer.h