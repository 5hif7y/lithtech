modelmgr.h