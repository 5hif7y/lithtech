multilinestringdlg.h