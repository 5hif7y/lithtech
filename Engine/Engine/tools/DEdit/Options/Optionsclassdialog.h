optionsclassdialog.h