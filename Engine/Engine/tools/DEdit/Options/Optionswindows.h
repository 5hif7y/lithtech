optionswindows.h