deditoptions.h