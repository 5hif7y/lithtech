optionsbase.h