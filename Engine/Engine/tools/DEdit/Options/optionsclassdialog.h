OptionsClassDialog.h