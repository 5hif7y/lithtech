optionsclipboard.h