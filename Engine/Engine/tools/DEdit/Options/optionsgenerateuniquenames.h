optionsgenerateuniquenames.h