optionsmisc.h