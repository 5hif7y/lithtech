optionsmodels.h