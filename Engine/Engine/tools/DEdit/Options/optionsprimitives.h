optionsprimitives.h