optionswarnings.h