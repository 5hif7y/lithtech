d_filemgr.h