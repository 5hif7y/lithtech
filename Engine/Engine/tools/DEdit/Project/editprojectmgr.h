EditProjectMgr.h