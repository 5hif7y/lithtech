editclipboard.h