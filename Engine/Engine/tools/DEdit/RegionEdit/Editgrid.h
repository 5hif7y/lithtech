editgrid.h