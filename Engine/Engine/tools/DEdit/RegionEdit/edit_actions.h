edit_actions.h