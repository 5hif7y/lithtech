undo_mgr.h