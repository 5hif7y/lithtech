wadtypes.h