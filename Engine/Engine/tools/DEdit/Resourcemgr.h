resourcemgr.h