rotateselection.h