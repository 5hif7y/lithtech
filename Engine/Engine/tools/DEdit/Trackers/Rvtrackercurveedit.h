rvtrackercurveedit.h