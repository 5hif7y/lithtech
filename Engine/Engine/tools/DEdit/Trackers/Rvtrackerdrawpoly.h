rvtrackerdrawpoly.h