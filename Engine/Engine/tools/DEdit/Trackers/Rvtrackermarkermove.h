rvtrackermarkermove.h