rvtrackerpolyscale.h