rvtrackervertscale.h