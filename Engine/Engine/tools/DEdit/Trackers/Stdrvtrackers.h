stdrvtrackers.h