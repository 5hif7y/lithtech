rvcommand.h