rvtrackerbrushsize.h