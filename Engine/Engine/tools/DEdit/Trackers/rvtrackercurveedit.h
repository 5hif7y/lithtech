RVTrackerCurveEdit.h