RVTrackerDrawPoly.h