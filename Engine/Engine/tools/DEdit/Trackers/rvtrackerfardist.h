RVTrackerFarDist.h