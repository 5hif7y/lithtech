rvtrackernodemove.h