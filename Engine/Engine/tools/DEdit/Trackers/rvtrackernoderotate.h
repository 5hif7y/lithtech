RVTrackerNodeRotate.h