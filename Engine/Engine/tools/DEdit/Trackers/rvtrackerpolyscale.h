RVTrackerPolyScale.h