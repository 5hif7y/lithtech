rvtrackertextwrap.h