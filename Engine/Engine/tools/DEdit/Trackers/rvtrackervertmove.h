RVTrackerVertMove.h