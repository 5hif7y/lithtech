RVTrackerVertScale.h