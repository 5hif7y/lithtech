rvtrackervertsnap.h