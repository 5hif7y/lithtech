trackermgr.h