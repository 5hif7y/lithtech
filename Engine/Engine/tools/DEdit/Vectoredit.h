vectoredit.h