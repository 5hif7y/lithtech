autotooltipctrl.h