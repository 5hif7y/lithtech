dedit.h