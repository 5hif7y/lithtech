dedit_concommand.h