deditinternal.h