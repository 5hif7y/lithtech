cyclemgr.h