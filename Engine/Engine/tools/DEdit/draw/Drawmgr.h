drawmgr.h