usefuldc.h