usefuldib.h