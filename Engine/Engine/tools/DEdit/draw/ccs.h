ccs.h