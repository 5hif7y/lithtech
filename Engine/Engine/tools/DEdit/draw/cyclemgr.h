CycleMgr.h