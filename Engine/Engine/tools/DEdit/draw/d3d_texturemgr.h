d3d_texturemgr.h