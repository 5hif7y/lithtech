dibbuffer.h