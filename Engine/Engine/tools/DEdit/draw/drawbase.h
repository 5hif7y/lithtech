drawbase.h