filepalette.h