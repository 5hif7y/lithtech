maptexturecoordsdlg.h