MultiLineStringDlg.h