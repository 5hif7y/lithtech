paletteedit.h