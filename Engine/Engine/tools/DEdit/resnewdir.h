resnewdir.h