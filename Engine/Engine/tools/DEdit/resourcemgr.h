ResourceMgr.h