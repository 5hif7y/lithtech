updateallobjects.h