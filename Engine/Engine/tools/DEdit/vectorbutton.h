vectorbutton.h