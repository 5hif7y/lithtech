dtxshellexextractor.h