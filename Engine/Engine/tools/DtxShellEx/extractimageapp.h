ExtractImageApp.h