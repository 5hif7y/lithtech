dtxviewdoc.h