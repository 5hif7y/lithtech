dtxview.h