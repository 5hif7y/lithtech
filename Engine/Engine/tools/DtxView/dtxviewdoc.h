DtxViewDoc.h