dtxviewview.h