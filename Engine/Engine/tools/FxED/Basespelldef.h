basespelldef.h