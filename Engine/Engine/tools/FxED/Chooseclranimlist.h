chooseclranimlist.h