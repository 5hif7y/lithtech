copydatadlg.h