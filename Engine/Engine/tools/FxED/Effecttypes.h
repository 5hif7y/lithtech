effecttypes.h