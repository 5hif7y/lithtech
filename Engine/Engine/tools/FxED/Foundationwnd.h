foundationwnd.h