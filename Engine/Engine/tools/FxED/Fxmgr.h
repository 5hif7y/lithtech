fxmgr.h