memarray.h