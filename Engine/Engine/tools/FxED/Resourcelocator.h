resourcelocator.h