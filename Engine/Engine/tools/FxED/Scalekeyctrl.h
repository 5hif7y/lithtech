scalekeyctrl.h