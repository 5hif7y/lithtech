spelldeftab.h