spelled.h