spelltabctrl.h