alterattributesdlg.h