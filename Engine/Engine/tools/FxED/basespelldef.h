BaseSpellDef.h