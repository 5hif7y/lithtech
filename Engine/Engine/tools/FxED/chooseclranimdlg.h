chooseclranimdlg.h