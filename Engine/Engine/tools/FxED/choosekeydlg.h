ChooseKeyDlg.h