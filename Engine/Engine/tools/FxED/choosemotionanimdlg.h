choosemotionanimdlg.h