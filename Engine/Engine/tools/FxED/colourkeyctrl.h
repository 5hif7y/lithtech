colourkeyctrl.h