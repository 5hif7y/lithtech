EditVectorDlg.h