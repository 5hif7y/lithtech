EffectTypes.h