FxMgr.h