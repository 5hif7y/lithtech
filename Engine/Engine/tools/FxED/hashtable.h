hashtable.h