ScaleKeyCtrl.h