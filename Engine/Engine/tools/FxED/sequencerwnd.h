sequencerwnd.h