SpellBaseParmDlg.h