SpellDefTab.h