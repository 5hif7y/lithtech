SpellDlgBar.h