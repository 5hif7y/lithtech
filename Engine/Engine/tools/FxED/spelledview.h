spelledview.h