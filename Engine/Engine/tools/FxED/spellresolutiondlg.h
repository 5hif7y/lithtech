spellresolutiondlg.h