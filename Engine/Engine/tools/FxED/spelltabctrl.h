SpellTabCtrl.h