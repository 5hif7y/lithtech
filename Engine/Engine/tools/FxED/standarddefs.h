standarddefs.h