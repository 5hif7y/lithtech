d3d_device.h