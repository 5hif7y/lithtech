heightmaptonormalmap.h