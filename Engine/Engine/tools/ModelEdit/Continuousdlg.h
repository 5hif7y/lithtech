continuousdlg.h