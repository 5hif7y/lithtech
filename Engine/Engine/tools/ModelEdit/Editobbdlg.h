editobbdlg.h