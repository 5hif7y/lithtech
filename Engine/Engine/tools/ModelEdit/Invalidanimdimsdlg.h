invalidanimdimsdlg.h