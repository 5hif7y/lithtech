lodedit.h