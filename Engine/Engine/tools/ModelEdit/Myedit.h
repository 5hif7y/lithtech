myedit.h