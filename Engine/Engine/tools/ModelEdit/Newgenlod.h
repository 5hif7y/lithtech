newgenlod.h