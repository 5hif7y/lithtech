piecemerge.h