weighteditdlg.h