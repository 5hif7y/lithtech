AnimFramerateDlg.h