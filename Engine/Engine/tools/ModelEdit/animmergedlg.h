AnimMergeDlg.h