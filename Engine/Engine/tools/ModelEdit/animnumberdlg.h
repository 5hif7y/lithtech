animnumberdlg.h