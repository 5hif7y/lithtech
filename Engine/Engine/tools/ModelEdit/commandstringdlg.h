commandstringdlg.h