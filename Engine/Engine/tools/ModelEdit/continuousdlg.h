ContinuousDlg.h