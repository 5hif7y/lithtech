EditOBBDlg.h