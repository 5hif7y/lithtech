exportd3d_dlg.h