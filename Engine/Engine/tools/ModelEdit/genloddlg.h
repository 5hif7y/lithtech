genloddlg.h