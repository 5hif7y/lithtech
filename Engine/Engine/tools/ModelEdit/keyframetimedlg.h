KeyframeTimeDlg.h