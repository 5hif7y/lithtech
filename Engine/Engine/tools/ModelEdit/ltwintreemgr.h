ltwintreemgr.h