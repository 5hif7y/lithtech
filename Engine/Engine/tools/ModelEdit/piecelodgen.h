piecelodgen.h