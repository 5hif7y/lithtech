piecematerialdlg.h