renamedlg.h