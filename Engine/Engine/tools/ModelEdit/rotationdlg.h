rotationdlg.h