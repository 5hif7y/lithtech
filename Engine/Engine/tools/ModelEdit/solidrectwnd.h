SolidRectWnd.h