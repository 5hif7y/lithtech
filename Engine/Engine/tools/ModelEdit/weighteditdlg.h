WeightEditDlg.h