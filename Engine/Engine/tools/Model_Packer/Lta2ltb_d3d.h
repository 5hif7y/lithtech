lta2ltb_d3d.h