manifold.h