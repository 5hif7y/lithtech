stripify.h