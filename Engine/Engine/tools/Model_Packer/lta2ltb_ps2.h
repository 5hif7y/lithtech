lta2ltb_ps2.h