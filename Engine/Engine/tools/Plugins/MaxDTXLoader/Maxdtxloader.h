maxdtxloader.h