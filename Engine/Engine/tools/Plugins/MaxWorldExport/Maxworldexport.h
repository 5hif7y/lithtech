maxworldexport.h