maxworldimport.h