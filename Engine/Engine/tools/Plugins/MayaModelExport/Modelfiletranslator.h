modelfiletranslator.h