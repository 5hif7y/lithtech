worldexportcommand.h