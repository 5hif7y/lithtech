worldimportfiletranslator.h