WorldImportFileTranslator.h