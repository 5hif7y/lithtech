dtxformat-sym.h