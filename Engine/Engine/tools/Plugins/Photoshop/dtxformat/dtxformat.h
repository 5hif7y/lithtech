dtxformat.h