dtxformatterminology.h