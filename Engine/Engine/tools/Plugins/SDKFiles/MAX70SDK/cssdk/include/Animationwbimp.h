animationwbimp.h