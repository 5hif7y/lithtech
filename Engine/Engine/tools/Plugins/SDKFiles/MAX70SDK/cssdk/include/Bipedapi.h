bipedapi.h