ourexp.h