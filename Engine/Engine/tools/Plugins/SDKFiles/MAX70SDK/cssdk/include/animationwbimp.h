AnimationWBImp.h