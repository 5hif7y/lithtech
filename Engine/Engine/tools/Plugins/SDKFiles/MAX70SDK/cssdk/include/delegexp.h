delegexp.h