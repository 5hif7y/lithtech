bmmlib.h