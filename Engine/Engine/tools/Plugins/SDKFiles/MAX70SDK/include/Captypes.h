captypes.h