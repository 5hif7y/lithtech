coreexp.h