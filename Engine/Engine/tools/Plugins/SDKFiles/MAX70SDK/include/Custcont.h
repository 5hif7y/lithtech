custcont.h