genshape.h