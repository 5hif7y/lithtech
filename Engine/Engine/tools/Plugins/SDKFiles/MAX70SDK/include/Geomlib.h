geomlib.h