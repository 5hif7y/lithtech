gfloat.h