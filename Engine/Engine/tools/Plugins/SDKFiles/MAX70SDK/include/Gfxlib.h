gfxlib.h