gupapi.h