guplib.h