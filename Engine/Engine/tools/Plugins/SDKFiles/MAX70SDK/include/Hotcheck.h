hotcheck.h