iBlockMgr.h