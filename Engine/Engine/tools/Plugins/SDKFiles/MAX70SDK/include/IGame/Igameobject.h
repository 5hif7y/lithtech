igameobject.h