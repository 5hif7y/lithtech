igameproperty.h