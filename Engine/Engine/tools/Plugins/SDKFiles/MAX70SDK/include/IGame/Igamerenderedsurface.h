igamerenderedsurface.h