iconversionmanager.h