IGameProperty.h