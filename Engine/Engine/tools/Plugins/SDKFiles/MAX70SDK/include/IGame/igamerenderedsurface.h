IGameRenderedSurface.h