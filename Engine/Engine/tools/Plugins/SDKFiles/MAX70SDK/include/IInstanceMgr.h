iInstanceMgr.h