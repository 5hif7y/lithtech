iLuminaire.h