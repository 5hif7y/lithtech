iaggregation.h