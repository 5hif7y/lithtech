ibrowser.h