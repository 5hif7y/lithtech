id3d9graphicswindow.h