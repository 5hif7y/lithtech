iglobaldxdisplaymanager.h