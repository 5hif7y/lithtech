ihardwarematerial.h