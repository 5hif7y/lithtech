ihardwaremnmesh.h