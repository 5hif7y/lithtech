ilayermanager.h