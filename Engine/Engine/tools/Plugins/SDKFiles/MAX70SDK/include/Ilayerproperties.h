ilayerproperties.h