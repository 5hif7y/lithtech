inodebakeproperties.h