iparamwire.h