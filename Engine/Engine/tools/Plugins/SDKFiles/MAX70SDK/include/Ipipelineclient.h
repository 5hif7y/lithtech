ipipelineclient.h