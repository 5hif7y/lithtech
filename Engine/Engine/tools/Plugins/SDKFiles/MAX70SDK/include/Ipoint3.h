ipoint3.h