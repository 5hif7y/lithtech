linklist.h