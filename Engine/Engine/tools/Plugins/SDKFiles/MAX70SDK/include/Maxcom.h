maxcom.h