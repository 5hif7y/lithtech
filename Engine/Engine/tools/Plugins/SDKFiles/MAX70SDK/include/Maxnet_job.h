maxnet_job.h