mcapdev.h