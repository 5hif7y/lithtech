meshdelta.h