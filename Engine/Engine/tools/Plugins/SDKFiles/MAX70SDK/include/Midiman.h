midiman.h