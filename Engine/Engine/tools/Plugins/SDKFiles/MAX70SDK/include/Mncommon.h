mncommon.h