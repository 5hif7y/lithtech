modstack.h