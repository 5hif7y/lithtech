mouseman.h