nodedisp.h