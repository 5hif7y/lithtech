osnapapi.h