partclib.h