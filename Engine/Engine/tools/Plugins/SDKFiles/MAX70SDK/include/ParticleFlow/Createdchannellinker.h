createdchannellinker.h