iparticlechannelacceleration.h