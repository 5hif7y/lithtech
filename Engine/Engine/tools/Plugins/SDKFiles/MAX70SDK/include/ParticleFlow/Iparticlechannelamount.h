iparticlechannelamount.h