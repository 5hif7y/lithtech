iparticlechannelid.h