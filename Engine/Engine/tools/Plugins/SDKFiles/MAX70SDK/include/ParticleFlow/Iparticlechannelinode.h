iparticlechannelinode.h