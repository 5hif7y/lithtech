iparticlechannellifespan.h