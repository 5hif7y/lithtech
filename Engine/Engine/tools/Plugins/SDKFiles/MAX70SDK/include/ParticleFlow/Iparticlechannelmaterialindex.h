iparticlechannelmaterialindex.h