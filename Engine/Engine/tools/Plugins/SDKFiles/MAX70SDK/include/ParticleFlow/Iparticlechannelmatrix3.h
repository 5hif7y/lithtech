iparticlechannelmatrix3.h