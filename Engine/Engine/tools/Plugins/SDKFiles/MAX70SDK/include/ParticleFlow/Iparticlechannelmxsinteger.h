iparticlechannelmxsinteger.h