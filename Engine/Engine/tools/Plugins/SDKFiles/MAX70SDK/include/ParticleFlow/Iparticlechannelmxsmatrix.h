iparticlechannelmxsmatrix.h