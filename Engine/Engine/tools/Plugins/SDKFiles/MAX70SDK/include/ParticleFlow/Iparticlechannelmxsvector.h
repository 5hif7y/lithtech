iparticlechannelmxsvector.h