iparticlechannelnew.h