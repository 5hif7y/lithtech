iparticlechannelorientation.h