iparticlechannelpoint3.h