iparticlechannelptv.h