iparticlechanneltabuvvert.h