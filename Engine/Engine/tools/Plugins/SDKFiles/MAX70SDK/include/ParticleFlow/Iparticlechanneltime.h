iparticlechanneltime.h