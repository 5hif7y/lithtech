iparticlegroup.h