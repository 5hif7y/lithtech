ipfactionlistpool.h