ipfoperator.h