particlechannelmask.h