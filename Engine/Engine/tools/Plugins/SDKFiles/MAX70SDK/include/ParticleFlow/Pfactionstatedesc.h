pfactionstatedesc.h