precisetimevalue.h