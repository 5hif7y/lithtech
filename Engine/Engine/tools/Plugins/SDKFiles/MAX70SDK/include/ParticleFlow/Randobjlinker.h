randobjlinker.h