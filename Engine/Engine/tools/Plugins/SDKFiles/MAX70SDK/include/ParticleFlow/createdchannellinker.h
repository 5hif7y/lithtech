CreatedChannelLinker.h