IChannelContainer.h