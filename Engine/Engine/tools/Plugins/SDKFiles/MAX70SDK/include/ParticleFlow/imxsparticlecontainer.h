IMXSParticleContainer.h