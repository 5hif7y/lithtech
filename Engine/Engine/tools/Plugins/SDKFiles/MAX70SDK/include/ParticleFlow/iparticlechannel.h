iparticlechannel.h