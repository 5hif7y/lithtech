IParticleChannelAcceleration.h