IParticleChannelAmount.h