IParticleChannelAngAxis.h