iparticlechannelbool.h