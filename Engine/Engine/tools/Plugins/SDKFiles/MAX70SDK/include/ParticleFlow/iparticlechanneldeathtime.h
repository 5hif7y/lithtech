IParticleChannelDeathTime.h