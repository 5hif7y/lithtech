IParticleChannelEventStart.h