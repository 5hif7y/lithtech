iparticlechannelfloat.h