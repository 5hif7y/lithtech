IParticleChannelINode.h