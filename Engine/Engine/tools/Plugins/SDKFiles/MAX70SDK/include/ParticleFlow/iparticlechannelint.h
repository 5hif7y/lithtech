iparticlechannelint.h