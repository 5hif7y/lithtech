IParticleChannelLifespan.h