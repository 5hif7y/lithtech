iparticlechannelmap.h