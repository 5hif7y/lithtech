IParticleChannelMaterialIndex.h