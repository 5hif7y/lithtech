IParticleChannelMatrix3.h