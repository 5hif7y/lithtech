iparticlechannelmesh.h