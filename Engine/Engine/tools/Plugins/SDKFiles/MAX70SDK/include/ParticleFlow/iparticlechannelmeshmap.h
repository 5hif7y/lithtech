iparticlechannelmeshmap.h