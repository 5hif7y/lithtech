iparticlechannelmxsfloat.h