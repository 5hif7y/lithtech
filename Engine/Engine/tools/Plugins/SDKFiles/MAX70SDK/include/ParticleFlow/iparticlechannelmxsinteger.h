IParticleChannelMXSInteger.h