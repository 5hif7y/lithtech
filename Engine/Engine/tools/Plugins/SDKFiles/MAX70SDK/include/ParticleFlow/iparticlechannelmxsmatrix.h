IParticleChannelMXSMatrix.h