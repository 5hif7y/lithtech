IParticleChannelMXSVector.h