IParticleChannelNew.h