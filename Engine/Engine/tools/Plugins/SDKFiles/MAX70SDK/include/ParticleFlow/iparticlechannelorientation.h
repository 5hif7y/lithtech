IParticleChannelOrientation.h