IParticleChannelPoint3.h