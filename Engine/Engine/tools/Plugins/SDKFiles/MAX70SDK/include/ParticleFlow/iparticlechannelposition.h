IParticleChannelPosition.h