IParticleChannelPTV.h