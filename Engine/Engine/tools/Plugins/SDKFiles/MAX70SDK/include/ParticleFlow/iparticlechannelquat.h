iparticlechannelquat.h