iparticlechannels.h