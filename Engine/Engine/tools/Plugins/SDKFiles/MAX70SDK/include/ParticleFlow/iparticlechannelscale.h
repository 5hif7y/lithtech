iparticlechannelscale.h