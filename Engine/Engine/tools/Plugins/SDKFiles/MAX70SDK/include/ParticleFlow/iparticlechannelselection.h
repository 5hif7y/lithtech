iparticlechannelselection.h