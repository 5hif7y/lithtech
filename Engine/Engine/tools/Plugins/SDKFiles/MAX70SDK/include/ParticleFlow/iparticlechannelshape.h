iparticlechannelshape.h