iparticlechannelshapetexture.h