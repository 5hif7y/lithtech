iparticlechannelspin.h