IParticleChannelTime.h