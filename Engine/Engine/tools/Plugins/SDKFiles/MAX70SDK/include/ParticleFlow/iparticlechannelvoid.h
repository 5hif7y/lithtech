iparticlechannelvoid.h