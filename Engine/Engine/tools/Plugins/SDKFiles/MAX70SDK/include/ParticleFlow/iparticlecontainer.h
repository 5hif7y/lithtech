iparticlecontainer.h