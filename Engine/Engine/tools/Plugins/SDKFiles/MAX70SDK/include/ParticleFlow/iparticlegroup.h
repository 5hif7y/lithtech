IParticleGroup.h