ipfactionstate.h