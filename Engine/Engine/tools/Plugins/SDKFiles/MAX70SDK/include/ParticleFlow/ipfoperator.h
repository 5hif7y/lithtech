IPFOperator.h