ipfsystempool.h