ipviewmanager.h