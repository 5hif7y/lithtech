oneclickcreatecallback.h