ParticleChannelMask.h