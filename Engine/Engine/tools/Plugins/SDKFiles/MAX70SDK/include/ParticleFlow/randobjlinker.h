RandObjLinker.h