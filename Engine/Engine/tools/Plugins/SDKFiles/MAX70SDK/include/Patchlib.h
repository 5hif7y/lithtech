patchlib.h