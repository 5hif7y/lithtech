pixelbuf.h