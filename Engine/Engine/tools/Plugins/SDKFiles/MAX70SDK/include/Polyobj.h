polyobj.h