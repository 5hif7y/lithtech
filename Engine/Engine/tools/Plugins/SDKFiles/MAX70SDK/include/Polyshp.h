polyshp.h