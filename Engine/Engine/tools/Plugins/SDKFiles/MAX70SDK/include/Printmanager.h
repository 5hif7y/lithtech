printmanager.h