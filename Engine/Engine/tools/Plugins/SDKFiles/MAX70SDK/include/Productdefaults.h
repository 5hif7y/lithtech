productdefaults.h