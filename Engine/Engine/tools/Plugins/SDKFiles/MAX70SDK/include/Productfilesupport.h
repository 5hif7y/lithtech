productfilesupport.h