radiosityMesh.h