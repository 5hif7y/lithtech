referencemgr.h