scanlinepagemgr.h