sceneapi.h