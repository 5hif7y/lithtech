setkeymode.h