shphier.h