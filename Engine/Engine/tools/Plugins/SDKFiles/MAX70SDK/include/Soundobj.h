soundobj.h