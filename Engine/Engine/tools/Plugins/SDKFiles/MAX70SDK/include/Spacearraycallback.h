spacearraycallback.h