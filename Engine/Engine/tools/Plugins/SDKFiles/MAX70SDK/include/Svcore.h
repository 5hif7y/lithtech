svcore.h