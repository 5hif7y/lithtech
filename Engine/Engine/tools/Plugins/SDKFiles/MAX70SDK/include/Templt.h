templt.h