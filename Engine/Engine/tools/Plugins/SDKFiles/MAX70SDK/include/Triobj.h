triobj.h