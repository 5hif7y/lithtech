animtbl.h