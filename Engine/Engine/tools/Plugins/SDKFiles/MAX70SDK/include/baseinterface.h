baseinterface.h