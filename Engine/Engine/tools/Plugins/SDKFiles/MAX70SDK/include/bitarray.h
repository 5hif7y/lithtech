bitarray.h