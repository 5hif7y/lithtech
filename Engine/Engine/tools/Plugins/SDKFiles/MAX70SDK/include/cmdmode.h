cmdmode.h