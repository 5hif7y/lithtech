custattrib.h