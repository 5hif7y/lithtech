decomp.h