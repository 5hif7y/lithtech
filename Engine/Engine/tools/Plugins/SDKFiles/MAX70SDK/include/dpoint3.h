dpoint3.h