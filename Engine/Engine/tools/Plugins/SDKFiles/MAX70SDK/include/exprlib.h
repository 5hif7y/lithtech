exprlib.h