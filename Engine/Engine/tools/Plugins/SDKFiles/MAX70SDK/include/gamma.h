gamma.h