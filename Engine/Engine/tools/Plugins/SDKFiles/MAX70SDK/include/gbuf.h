gbuf.h