gencam.h