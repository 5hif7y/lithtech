geotableitem.h