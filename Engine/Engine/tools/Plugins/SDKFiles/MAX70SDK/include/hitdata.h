hitdata.h