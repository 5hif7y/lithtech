iadtcategory.h