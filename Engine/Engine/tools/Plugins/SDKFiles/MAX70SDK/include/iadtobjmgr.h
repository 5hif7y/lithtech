iadtobjmgr.h