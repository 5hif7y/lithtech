iassemblymgr.h