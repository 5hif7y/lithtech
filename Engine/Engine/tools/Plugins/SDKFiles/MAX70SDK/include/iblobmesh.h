IBlobMesh.h