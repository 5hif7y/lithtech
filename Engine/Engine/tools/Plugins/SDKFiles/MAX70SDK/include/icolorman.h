icolorman.h