icommandpanel.h