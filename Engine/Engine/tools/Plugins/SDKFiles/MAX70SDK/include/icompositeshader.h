icompositeshader.h