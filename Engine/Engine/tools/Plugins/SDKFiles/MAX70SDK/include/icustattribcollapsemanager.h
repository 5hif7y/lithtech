icustattribcollapsemanager.h