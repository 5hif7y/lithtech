id3dgraphicswindow.h