idxmaterial.h