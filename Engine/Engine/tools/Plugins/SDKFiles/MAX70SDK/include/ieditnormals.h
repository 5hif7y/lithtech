ieditnormals.h