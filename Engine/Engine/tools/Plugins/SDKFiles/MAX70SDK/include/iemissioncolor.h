iemissioncolor.h