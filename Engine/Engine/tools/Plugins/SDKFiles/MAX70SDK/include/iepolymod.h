iepolymod.h