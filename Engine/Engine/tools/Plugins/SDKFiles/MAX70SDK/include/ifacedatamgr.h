ifacedatamgr.h