IFrameTagManager.h