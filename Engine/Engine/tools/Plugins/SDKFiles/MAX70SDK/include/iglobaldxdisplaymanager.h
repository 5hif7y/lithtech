IGlobalDXDisplayManager.h