ihardwarerenderer.h