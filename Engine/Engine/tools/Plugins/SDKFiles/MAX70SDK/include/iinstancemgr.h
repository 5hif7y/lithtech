iinstancemgr.h