ILayerProperties.h