imacroscript.h