impexpintf.h