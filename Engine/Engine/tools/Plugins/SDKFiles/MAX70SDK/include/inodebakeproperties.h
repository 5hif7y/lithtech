INodeBakeProperties.h