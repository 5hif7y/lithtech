INodeExposure.h