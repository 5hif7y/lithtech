inodegiproperties.h