inodelayerproperties.h