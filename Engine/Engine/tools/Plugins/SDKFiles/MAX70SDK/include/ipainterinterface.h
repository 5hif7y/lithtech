ipainterinterface.h