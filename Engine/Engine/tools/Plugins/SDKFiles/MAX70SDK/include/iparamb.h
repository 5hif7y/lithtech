iparamb.h