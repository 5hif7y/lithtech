iparamb2.h