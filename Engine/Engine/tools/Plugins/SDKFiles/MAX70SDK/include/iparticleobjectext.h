iparticleobjectext.h