ipoint2.h