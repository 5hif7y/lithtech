iprojection_workingmodelinfo.h