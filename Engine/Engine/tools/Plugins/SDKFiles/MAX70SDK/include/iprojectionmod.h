iprojectionmod.h