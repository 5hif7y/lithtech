iprojectionrenderhandler.h