ISkinWrapPatch.h