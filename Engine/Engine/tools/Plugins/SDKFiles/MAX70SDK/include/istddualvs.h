istddualvs.h