ITabDialog.h