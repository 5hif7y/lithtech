keyreduc.h