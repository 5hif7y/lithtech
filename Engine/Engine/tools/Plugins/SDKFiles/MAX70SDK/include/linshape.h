linshape.h