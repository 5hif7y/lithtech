lslights.h