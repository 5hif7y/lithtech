macrorec.h