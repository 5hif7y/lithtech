manipulator.h