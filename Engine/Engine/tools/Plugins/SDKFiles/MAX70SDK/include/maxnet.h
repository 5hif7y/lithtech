maxnet.h