maxnet_archive.h