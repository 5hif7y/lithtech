maxnet_file.h