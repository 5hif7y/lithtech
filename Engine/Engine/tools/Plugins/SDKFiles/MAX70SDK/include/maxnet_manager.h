maxnet_manager.h