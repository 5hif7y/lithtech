maxnet_platform.h