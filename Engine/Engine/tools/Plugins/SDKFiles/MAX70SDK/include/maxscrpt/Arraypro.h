arraypro.h