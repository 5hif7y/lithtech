arrays.h