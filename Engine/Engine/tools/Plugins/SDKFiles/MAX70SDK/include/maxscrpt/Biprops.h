biprops.h