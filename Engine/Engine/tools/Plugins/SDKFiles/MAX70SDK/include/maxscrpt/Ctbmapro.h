ctbmapro.h