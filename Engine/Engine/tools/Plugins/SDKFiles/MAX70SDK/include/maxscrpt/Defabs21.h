defabs21.h