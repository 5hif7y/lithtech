defabsfn.h