funcs.h