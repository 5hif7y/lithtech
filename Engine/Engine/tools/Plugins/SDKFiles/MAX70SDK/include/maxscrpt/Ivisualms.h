ivisualms.h