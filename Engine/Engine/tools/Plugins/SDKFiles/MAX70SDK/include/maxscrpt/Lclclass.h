lclclass.h