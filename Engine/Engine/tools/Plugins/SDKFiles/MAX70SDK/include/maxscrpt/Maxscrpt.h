maxscrpt.h