mscustattrib.h