mszippackage.h