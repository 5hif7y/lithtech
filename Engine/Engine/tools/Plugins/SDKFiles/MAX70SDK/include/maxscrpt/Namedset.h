namedset.h