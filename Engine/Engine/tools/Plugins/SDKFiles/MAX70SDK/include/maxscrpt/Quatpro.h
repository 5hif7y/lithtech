quatpro.h