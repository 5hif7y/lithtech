streampr.h