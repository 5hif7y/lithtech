thrdlcls.h