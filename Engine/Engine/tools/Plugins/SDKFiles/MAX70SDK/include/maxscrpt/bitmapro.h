bitmapro.h