defextfn.h