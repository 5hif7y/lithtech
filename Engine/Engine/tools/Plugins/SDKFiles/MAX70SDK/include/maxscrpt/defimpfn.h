defimpfn.h