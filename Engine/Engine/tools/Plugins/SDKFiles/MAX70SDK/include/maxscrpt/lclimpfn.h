lclimpfn.h