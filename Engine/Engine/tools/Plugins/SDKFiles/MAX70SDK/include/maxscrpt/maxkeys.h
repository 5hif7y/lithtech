maxkeys.h