maxmats.h