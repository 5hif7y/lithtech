maxnurbs.h