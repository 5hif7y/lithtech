mousetool.h