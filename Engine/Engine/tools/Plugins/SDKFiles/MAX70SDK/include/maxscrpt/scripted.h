scripted.h