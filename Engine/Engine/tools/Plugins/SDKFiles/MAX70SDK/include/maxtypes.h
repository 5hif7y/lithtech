maxtypes.h