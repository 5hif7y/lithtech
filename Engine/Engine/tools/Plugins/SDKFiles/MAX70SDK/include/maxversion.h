maxversion.h