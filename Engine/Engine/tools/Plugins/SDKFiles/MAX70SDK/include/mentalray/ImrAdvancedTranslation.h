imrAdvancedTranslation.h