imrShaderClassDesc.h