imrshaderclassdesc.h