mentalrayInMax.h