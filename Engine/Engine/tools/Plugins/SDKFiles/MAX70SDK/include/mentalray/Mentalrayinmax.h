mentalrayinmax.h