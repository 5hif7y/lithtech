imradvancedtranslation.h