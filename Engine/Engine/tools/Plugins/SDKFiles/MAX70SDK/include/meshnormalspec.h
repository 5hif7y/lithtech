meshnormalspec.h