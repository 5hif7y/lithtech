mnmesh.h