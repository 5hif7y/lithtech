MNNormalSpec.h