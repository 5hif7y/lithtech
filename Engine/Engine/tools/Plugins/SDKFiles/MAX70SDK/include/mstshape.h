mstshape.h