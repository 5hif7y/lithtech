nametab.h