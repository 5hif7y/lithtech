nsclip.h