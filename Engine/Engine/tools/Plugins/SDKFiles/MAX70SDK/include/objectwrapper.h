objectwrapper.h