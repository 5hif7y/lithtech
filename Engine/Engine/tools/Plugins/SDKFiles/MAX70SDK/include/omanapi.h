omanapi.h