osnap.h