osnaphit.h