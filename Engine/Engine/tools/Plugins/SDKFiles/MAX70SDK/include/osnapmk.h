osnapmk.h