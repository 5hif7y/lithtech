particle.h