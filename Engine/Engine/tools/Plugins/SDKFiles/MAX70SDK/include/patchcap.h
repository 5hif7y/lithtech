patchcap.h