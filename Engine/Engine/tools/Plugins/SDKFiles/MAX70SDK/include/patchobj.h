patchobj.h