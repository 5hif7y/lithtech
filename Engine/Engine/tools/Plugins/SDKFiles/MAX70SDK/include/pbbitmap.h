pbbitmap.h