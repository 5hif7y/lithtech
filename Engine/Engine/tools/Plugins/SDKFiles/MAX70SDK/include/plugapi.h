plugapi.h