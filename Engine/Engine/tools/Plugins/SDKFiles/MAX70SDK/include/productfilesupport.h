ProductFileSupport.h