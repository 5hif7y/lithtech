ptrvec.h