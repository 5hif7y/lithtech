samplers.h