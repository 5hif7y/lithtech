scenetraversal.h