shadbuf.h