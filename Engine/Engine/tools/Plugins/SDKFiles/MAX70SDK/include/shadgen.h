shadgen.h