simpmod.h