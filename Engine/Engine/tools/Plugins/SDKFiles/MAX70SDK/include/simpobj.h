simpobj.h