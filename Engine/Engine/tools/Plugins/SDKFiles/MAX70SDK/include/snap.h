snap.h