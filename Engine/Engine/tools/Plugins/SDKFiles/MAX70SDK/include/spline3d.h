spline3d.h