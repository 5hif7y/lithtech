splshape.h