xtcobject.h