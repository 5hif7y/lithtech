mangle.h