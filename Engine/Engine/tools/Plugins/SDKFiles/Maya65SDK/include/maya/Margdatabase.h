margdatabase.h