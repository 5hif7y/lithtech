marraydatahandle.h