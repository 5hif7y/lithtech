mattributespec.h