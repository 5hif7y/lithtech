mcomputation.h