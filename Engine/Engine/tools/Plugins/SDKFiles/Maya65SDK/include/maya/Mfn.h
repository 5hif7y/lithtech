mfn.h