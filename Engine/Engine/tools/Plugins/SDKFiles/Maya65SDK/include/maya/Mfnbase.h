mfnbase.h