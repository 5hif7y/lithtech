mfncirclesweepmanip.h