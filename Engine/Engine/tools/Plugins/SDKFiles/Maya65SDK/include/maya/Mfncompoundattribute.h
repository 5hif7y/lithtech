mfncompoundattribute.h