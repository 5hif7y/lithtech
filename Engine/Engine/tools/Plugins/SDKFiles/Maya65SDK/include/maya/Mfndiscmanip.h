mfndiscmanip.h