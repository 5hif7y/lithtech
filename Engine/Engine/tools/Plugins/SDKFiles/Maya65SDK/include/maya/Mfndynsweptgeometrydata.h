mfndynsweptgeometrydata.h