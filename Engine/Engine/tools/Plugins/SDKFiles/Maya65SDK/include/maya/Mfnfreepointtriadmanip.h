mfnfreepointtriadmanip.h