mfniksolver.h