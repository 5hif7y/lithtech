mfnintarraydata.h