mfnkeyframedeltainftype.h