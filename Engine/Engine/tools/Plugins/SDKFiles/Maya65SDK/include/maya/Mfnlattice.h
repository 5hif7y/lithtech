mfnlattice.h