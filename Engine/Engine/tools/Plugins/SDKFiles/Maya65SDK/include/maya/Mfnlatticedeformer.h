mfnlatticedeformer.h