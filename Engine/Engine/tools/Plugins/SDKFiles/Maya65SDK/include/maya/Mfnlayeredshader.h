mfnlayeredshader.h