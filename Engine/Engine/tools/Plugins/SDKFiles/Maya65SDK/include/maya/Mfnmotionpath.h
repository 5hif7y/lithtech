mfnmotionpath.h