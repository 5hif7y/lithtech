mfnnumericdata.h