mfnnurbscurvedata.h