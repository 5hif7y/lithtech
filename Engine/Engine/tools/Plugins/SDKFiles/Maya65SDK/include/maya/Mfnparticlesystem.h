mfnparticlesystem.h