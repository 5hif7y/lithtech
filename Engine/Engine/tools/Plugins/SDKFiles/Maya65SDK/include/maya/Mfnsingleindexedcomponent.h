mfnsingleindexedcomponent.h