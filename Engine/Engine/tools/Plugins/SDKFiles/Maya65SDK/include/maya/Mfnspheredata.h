mfnspheredata.h