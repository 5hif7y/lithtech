mfnvectorarraydata.h