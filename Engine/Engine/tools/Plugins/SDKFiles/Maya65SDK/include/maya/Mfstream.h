mfstream.h