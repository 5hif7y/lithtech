mlibrary.h