mmatrix.h