mpxpolytrg.h