mpxspringnode.h