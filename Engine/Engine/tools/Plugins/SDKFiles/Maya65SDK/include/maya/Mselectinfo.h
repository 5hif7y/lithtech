mselectinfo.h