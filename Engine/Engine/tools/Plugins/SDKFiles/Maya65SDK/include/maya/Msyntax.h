msyntax.h