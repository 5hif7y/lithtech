mtimearray.h