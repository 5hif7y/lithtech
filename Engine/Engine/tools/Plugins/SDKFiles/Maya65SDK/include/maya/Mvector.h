mvector.h