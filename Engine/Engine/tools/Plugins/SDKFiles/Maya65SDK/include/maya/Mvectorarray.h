mvectorarray.h