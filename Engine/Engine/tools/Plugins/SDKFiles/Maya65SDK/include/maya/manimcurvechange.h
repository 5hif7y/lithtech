MAnimCurveChange.h