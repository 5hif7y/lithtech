MAnimCurveClipboard.h