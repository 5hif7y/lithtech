MAnimCurveClipboardItem.h