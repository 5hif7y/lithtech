MAnimCurveClipboardItemArray.h