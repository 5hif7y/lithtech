MAttributeSpec.h