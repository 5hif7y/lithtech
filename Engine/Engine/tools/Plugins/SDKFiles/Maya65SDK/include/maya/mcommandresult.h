mcommandresult.h