MComputation.h