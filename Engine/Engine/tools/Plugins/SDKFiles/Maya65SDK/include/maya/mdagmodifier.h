mdagmodifier.h