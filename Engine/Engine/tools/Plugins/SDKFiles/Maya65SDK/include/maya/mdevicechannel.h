mdevicechannel.h