mdistance.h