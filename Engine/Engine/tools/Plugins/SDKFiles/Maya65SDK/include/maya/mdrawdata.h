mdrawdata.h