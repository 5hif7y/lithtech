mdrawinfo.h