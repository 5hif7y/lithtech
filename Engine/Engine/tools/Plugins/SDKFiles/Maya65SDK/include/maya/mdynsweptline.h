MDynSweptLine.h