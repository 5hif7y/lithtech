MDynSweptTriangle.h