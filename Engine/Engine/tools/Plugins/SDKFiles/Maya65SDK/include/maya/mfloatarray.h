MFloatArray.h