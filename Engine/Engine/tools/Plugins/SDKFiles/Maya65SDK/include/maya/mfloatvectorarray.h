mfloatvectorarray.h