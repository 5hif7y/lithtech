MFnAmbientLight.h