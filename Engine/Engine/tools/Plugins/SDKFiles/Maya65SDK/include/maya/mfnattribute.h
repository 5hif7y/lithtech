mfnattribute.h