MFnClip.h