MFnCompoundAttribute.h