mfncurvesegmentmanip.h