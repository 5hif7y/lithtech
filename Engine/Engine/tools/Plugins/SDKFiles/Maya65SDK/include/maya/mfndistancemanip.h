mfndistancemanip.h