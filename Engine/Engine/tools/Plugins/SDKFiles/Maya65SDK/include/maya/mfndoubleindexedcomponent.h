mfndoubleindexedcomponent.h