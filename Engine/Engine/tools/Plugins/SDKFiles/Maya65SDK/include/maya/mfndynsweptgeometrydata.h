MFnDynSweptGeometryData.h