mfnexpression.h