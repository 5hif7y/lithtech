mfngenericattribute.h