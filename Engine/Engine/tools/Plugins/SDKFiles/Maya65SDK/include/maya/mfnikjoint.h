mfnikjoint.h