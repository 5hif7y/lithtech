MFnKeyframeDelta.h