mfnkeyframedeltaaddremove.h