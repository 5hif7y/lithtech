MFnKeyframeDeltaBlockAddRemove.h