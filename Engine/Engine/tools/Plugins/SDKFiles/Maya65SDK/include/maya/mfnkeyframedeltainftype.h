MFnKeyframeDeltaInfType.h