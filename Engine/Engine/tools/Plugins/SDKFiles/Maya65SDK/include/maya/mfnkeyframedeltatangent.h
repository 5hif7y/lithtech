MFnKeyframeDeltaTangent.h