mfnlatticedata.h