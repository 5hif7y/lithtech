mfnnewtonfield.h