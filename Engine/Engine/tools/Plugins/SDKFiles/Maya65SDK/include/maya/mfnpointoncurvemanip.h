mfnpointoncurvemanip.h