mfnstringdata.h