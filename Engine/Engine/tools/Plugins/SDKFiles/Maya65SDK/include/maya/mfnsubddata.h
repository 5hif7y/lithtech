mfnsubddata.h