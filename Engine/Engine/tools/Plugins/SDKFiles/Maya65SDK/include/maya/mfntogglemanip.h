mfntogglemanip.h