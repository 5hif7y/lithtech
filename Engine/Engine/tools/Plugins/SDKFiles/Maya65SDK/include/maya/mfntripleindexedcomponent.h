MFnTripleIndexedComponent.h