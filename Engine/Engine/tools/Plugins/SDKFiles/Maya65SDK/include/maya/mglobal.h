mglobal.h