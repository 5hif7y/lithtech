mintarray.h