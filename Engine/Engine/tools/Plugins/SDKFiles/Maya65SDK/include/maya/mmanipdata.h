mmanipdata.h