mmessage.h