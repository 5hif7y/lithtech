mmodelmessage.h