mnodemessage.h