mobjectarray.h