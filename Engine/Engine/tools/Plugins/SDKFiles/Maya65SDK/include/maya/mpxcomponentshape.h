mpxcomponentshape.h