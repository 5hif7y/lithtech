MPxEmitterNode.h