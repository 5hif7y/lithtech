mpxfiletranslator.h