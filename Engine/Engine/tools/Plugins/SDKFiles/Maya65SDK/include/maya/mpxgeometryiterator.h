MPxGeometryIterator.h