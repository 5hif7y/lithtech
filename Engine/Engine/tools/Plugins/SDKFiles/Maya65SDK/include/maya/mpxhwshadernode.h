mpxhwshadernode.h