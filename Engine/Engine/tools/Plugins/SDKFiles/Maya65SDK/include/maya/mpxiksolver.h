mpxiksolver.h