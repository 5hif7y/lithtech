mpxnode.h