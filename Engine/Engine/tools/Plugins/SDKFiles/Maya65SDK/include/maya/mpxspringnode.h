MPxSpringNode.h