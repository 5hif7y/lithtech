mpxtoolcommand.h