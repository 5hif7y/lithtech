mquaternion.h