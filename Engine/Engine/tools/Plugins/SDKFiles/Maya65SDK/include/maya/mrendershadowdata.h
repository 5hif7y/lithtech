mrendershadowdata.h