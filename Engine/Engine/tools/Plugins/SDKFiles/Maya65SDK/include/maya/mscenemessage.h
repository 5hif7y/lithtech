mscenemessage.h