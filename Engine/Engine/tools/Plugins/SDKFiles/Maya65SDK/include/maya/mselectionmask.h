MSelectionMask.h