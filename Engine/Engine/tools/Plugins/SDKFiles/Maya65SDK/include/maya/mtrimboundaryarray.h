mtrimboundaryarray.h