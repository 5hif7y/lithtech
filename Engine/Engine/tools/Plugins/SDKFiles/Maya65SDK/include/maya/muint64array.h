muint64array.h