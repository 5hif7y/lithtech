MUintArray.h