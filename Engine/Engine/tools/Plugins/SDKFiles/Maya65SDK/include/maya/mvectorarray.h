MVectorArray.h