manimcontrol.h