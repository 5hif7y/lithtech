manimcurveclipboard.h