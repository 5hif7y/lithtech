manimcurveclipboarditemarray.h