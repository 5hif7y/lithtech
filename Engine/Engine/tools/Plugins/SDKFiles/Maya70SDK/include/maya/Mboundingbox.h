mboundingbox.h