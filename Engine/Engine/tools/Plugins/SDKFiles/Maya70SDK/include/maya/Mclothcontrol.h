mclothcontrol.h