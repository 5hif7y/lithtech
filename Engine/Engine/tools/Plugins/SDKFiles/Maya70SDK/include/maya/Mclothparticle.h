mclothparticle.h