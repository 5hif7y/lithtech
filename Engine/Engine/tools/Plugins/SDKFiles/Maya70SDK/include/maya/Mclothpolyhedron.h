mclothpolyhedron.h