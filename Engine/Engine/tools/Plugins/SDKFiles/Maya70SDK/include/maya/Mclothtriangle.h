mclothtriangle.h