mconditionmessage.h