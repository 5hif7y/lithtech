mdagmessage.h