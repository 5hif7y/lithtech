mdagpath.h