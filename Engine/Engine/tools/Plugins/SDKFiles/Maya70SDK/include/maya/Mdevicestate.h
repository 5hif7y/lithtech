mdevicestate.h