mdgcontext.h