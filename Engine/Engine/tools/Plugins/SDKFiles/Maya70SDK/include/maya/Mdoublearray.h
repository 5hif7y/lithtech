mdoublearray.h