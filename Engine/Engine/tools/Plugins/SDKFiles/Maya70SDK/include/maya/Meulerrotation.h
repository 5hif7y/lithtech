meulerrotation.h