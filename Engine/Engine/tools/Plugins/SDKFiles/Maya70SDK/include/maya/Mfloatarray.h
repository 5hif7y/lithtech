mfloatarray.h