mfnarrayattrsdata.h