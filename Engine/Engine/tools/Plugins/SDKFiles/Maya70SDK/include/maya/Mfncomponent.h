mfncomponent.h