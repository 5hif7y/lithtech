mfndirectionmanip.h