mfndoublearraydata.h