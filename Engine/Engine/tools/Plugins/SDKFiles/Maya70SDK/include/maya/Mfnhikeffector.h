mfnhikeffector.h