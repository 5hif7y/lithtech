mfnikeffector.h