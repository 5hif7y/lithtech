mfnkeyframedeltascale.h