mfnmanip3d.h