mfnrotatemanip.h