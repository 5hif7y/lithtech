mfntripleindexedcomponent.h