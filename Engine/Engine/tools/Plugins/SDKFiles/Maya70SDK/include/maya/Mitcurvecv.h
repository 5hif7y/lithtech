mitcurvecv.h