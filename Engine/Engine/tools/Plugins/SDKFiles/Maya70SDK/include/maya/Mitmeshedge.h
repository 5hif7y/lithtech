mitmeshedge.h