mitsubdvertex.h