mobjectsetmessage.h