mplugarray.h