mpxemitternode.h