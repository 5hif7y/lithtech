mpxfluidemitternode.h