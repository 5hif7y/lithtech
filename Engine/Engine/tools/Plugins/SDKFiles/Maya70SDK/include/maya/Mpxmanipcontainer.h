mpxmanipcontainer.h