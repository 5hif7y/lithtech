mselectionlist.h