msimple.h