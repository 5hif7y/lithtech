musereventmessage.h