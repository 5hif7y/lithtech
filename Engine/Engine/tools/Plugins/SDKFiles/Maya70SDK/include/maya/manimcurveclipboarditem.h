manimcurveclipboarditem.h