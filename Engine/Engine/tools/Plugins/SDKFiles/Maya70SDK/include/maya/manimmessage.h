manimmessage.h