manimutil.h