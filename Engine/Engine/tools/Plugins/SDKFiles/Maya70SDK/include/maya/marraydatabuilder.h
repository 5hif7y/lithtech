marraydatabuilder.h