MAttributeSpecArray.h