MClothEdge.h