mclothmaterial.h