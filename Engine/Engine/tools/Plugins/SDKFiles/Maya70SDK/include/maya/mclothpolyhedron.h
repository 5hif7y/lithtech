MClothPolyhedron.h