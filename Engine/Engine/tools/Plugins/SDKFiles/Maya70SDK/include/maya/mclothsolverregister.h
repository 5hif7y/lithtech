mclothsolverregister.h