mclothtypes.h