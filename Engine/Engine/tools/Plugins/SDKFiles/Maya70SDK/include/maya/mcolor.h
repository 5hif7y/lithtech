mcolor.h