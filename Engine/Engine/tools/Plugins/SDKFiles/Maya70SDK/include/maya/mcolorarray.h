mcolorarray.h