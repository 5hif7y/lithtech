mcommandmessage.h