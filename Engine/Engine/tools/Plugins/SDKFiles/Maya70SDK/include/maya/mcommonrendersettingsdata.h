mcommonrendersettingsdata.h