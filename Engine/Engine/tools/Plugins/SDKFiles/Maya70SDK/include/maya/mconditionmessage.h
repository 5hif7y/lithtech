MConditionMessage.h