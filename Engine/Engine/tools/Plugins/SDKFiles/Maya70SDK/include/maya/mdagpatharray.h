mdagpatharray.h