MDeviceState.h