MDGMessage.h