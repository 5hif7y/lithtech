mdgmodifier.h