mdynsweptline.h