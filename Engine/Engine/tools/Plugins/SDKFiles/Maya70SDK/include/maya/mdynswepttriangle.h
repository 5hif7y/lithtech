mdynswepttriangle.h