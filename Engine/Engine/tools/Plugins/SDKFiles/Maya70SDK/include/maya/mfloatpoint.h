mfloatpoint.h