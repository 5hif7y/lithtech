mfloatpointarray.h