mfnanimcurve.h