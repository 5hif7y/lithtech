mfncamera.h