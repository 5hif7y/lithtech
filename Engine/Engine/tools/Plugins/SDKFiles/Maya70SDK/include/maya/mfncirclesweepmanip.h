MFnCircleSweepManip.h