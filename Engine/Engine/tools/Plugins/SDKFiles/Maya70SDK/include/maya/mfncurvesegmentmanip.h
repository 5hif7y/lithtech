MFnCurveSegmentManip.h