mfnenumattribute.h