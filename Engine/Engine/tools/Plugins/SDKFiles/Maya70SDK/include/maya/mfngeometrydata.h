mfngeometrydata.h