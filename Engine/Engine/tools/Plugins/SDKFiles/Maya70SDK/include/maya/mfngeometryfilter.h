mfngeometryfilter.h