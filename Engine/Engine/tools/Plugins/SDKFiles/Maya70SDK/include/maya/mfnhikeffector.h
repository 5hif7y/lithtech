MFnHikEffector.h