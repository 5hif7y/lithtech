MFnKeyframeDeltaScale.h