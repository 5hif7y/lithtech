mfnkeyframedeltaweighted.h