MFnLattice.h