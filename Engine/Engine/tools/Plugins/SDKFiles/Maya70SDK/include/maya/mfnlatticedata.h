MFnLatticeData.h