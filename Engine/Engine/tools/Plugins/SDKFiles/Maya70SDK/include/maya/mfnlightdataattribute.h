MFnLightDataAttribute.h