mfnmatrixdata.h