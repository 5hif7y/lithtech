mfnmessageattribute.h