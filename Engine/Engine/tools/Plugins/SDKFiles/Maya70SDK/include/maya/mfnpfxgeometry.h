mfnpfxgeometry.h