mfnplugindata.h