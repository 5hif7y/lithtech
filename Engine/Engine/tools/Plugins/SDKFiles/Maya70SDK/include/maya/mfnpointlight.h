mfnpointlight.h