mfnscalemanip.h