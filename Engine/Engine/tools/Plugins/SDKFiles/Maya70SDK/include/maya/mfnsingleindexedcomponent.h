MFnSingleIndexedComponent.h