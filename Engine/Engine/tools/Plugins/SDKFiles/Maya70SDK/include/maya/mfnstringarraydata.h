mfnstringarraydata.h