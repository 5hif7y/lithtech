MFnTypedAttribute.h