mfnweightgeometryfilter.h