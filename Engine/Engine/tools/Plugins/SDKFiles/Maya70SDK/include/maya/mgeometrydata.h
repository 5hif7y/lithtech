mgeometrydata.h