MGlobal.h