mhardwarerenderer.h