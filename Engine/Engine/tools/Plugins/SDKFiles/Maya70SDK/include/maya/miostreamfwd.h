miostreamfwd.h