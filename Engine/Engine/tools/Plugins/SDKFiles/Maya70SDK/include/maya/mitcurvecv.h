MItCurveCV.h