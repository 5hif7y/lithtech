mitmeshvertex.h