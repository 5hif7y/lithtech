mitsubdedge.h