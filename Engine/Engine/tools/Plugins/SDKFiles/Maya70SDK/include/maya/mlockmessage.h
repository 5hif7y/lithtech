mlockmessage.h