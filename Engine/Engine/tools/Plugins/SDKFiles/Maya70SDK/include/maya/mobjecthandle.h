MObjectHandle.h