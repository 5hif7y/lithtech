MPlugArray.h