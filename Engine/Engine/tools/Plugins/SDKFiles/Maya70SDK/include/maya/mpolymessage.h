mpolymessage.h