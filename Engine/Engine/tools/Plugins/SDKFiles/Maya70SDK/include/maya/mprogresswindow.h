MProgressWindow.h