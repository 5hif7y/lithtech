mpxcommand.h