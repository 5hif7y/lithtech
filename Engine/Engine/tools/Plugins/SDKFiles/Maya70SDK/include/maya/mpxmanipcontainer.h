MPxManipContainer.h