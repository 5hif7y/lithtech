mpxmidiinputdevice.h