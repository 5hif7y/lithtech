mpxmodeleditorcommand.h