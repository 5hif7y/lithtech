MRampAttribute.h