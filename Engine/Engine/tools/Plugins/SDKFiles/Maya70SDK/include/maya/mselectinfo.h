MSelectInfo.h