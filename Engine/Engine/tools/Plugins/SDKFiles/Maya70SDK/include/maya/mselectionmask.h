mselectionmask.h