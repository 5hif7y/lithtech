mstringarray.h