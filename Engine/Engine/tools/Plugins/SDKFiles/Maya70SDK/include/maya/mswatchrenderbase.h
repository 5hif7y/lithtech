mswatchrenderbase.h