mswatchrenderregister.h