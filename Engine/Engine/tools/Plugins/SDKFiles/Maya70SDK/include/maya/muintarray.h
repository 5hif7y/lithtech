muintarray.h