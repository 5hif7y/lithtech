admAGMTypes.h