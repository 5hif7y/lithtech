admEntry.h