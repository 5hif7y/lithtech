admHostInit.h