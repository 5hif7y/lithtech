admHostInitUnicode.h