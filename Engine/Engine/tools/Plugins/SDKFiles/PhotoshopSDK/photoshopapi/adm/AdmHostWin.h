admHostWin.h