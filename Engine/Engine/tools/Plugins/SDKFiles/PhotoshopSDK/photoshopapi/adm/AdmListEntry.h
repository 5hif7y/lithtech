admListEntry.h