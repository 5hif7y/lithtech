admcustomresource.h