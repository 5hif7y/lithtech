admdialoggroup.h