admhostinitunicode.h