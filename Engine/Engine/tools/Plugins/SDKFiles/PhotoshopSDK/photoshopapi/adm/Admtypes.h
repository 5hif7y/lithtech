admtypes.h