admversion.h