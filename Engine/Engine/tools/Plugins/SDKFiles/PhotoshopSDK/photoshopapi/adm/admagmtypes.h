admagmtypes.h