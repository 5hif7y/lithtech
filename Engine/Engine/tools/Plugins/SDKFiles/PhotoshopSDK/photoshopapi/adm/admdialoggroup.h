admDialogGroup.h