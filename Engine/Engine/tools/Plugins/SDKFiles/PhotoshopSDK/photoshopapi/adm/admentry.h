admentry.h