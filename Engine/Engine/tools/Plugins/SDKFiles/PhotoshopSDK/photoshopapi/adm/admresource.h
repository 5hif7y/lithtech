admResource.h