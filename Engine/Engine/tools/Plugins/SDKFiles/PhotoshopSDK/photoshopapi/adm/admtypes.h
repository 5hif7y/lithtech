admTypes.h