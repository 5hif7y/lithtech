admbasicold.h