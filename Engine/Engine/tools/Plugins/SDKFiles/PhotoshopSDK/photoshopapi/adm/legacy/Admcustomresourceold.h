admcustomresourceold.h