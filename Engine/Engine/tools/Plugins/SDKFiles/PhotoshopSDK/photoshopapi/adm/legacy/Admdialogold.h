admdialogold.h