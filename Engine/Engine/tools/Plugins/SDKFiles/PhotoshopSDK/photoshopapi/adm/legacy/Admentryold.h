admentryold.h