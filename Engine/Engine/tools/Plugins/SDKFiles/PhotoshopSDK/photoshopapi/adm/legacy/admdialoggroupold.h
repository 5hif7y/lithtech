admdialoggroupold.h