admhostold.h