admitemold.h