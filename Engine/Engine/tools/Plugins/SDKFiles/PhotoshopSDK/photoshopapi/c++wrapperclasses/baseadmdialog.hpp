BaseADMDialog.hpp