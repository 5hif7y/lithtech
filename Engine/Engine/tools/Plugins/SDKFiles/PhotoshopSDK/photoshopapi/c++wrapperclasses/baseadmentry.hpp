BaseADMEntry.hpp