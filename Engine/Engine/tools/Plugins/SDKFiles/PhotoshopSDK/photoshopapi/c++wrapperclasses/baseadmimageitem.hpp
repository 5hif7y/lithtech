BaseADMImageItem.hpp