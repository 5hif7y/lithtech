BaseADMItem.hpp