BaseADMListEntry.hpp