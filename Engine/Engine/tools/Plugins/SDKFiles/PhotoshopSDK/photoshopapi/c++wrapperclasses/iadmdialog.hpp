IADMDialog.hpp