IADMIcon.hpp