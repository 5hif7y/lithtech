IADMImage.hpp