IADMItem.hpp