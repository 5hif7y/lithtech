IADMListEntry.hpp