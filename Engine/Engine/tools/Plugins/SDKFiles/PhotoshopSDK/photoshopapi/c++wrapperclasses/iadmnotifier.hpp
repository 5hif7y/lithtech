IADMNotifier.hpp