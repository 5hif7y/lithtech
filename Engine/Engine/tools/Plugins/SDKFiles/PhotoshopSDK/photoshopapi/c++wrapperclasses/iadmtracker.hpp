IADMTracker.hpp