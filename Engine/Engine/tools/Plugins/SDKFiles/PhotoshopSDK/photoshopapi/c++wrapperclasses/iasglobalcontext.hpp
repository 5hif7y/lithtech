iasGlobalContext.hpp