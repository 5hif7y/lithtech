iasRect.hpp