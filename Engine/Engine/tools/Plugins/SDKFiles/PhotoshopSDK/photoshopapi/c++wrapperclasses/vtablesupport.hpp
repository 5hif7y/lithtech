vtablesupport.hpp