asConfig.h