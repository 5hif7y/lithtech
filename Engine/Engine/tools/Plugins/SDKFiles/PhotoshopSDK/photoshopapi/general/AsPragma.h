asPragma.h