asconfig.h