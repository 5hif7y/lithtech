asdatastream.h