aslib.h