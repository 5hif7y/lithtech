asnamespace.h