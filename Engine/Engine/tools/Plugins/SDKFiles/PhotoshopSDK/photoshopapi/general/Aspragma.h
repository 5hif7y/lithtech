aspragma.h