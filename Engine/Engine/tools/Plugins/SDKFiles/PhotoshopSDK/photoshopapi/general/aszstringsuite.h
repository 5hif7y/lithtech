aszstringsuite.h