pibuffersuite.h