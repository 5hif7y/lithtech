pichannelportoperations.h