piresdefines.h