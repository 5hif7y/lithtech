pistringterminology.h