pierrorsuite.h