pigeneral.h