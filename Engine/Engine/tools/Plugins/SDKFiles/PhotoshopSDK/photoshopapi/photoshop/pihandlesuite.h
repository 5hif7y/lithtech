pihandlesuite.h