spadapts.h