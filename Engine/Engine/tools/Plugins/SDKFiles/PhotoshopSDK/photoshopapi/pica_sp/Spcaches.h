spcaches.h