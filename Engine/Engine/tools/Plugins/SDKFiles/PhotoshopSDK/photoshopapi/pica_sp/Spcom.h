spcom.h