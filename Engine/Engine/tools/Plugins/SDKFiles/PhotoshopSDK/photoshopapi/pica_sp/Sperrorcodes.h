sperrorcodes.h