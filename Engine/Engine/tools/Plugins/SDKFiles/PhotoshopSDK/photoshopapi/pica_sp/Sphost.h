sphost.h