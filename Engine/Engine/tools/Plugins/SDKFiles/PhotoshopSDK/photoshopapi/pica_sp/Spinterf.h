spinterf.h