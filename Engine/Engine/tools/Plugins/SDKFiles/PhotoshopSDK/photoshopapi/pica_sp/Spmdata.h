spmdata.h