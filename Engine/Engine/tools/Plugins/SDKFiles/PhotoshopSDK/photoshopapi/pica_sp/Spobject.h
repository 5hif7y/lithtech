spobject.h