spprops.h