spstsprp.h