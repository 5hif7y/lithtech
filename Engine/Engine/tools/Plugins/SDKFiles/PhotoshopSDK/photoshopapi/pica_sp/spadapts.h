SPAdapts.h