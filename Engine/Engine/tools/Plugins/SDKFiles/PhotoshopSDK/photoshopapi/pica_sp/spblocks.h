spblocks.h