SPCOM.h