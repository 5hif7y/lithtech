sperrors.h