SPHost.h