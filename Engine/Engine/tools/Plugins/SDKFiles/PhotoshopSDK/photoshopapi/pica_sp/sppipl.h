sppipl.h