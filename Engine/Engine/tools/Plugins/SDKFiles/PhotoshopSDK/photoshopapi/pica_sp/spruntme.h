spruntme.h