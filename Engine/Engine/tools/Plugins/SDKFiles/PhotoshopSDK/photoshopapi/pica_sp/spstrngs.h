spstrngs.h