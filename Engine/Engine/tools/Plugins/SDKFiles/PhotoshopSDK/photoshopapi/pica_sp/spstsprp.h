SPSTSPrp.h