fileinfosearchreplacedlg.h