fileinfosearchreplace.h