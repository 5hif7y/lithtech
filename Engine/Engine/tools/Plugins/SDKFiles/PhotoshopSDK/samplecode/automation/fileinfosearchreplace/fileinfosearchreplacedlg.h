FileInfoSearchReplaceDlg.h