FrameSelect-sym.h