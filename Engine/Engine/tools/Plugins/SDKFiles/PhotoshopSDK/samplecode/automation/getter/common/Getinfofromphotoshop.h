getinfofromphotoshop.h