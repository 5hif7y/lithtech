GetInfoFromPhotoshop.h