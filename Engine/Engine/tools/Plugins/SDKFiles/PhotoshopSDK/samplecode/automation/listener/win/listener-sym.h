Listener-sym.h