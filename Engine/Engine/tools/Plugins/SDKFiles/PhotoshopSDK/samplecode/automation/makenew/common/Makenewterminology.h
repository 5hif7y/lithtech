makenewterminology.h