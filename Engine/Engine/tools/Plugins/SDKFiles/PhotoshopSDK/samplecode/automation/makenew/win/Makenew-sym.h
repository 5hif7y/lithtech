makenew-sym.h