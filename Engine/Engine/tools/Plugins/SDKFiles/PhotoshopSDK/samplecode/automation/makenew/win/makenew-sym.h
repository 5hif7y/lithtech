MakeNew-sym.h