polygonselect-sym.h