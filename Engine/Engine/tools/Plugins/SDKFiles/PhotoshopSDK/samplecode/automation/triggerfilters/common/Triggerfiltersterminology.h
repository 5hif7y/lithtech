triggerfiltersterminology.h