nearestbase.h