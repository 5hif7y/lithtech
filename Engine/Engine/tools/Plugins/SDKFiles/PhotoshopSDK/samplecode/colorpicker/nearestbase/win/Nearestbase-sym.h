nearestbase-sym.h