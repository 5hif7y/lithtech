NearestBase-sym.h