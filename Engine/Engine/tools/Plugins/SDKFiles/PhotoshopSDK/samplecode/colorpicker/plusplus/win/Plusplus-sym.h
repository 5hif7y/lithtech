plusplus-sym.h