PlusPlus-sym.h