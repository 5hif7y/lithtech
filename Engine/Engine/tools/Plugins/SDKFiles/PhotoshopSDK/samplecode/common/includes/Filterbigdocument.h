filterbigdocument.h