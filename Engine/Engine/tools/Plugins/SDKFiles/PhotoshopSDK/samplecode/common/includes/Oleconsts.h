oleconsts.h