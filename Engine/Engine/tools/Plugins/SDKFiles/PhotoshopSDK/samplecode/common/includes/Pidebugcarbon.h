pidebugcarbon.h