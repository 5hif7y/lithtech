propertyutils.h