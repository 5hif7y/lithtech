selectionplugin.h