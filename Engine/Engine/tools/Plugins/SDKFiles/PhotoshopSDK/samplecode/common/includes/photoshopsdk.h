photoshopsdk.h