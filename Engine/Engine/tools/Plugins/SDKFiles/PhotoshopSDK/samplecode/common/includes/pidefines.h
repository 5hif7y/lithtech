pidefines.h