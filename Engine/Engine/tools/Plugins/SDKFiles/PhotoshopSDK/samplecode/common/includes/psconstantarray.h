psconstantarray.h