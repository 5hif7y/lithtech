typelibrary.h