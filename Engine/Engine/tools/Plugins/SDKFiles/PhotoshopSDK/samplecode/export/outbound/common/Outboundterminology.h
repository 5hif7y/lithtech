outboundterminology.h