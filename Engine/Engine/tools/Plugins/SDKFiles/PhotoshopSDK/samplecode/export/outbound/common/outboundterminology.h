OutboundTerminology.h