Outbound-sym.h