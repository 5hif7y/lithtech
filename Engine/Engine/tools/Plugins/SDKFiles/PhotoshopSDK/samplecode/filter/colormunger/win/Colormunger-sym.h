colormunger-sym.h