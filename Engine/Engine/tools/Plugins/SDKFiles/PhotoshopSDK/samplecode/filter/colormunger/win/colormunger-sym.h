ColorMunger-sym.h