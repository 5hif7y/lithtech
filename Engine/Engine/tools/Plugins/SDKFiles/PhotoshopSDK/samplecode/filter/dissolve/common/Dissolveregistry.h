dissolveregistry.h