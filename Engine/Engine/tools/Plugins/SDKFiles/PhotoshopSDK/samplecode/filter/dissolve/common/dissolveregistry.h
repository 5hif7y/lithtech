DissolveRegistry.h