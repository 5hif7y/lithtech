dissolvescripting.h