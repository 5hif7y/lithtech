MFCPlugIn.h