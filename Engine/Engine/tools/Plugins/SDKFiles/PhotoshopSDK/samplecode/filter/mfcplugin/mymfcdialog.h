mymfcdialog.h