poormanstypetool.h