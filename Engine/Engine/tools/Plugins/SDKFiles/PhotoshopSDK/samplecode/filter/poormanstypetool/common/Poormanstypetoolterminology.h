poormanstypetoolterminology.h