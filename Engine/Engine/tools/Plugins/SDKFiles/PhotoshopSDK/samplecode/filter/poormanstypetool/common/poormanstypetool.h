PoorMansTypeTool.h