poormanstypetool-sym.h