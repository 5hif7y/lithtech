propetizerterminology.h