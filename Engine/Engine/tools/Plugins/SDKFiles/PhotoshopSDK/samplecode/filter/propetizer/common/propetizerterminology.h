PropetizerTerminology.h