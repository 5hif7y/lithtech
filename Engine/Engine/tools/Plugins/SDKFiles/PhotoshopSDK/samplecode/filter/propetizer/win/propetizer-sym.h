Propetizer-sym.h