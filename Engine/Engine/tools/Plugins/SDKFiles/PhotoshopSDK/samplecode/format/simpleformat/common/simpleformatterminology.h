simpleformatterminology.h