simpleformat-sym.h