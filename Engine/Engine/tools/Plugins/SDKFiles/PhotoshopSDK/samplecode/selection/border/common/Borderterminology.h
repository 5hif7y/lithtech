borderterminology.h