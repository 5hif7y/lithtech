IdleTerminology.h