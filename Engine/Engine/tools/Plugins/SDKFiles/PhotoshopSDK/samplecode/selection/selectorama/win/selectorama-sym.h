Selectorama-sym.h