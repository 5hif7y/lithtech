shapeterminology.h