applyambientoverride.h