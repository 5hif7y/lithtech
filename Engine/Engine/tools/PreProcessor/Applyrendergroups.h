applyrendergroups.h