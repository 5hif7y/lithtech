bspgen.h