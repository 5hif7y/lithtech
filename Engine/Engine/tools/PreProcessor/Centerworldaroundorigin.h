centerworldaroundorigin.h