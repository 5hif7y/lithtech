convertscatter.h