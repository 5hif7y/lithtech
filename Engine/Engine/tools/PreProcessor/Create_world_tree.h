create_world_tree.h