createpolyedges.h