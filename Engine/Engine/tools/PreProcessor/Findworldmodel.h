findworldmodel.h