lightfragmentmaker.h