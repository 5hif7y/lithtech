lightingbsp.h