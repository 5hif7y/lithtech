lightmapmaker.h