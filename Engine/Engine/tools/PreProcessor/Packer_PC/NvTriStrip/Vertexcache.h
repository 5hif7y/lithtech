vertexcache.h