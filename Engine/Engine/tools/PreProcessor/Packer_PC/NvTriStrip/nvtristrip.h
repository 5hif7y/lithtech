nvtristrip.h