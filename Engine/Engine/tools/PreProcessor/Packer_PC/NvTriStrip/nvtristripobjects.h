nvtristripobjects.h