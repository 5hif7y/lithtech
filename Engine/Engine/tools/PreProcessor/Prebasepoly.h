prebasepoly.h