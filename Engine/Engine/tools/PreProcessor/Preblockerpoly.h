preblockerpoly.h