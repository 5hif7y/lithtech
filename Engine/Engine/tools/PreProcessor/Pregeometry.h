pregeometry.h