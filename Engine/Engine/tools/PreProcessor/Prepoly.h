prepoly.h