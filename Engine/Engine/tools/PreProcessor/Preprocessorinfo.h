preprocessorinfo.h