preprocpackerimpl.h