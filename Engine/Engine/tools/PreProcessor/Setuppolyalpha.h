setuppolyalpha.h