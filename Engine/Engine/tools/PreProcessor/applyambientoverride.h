ApplyAmbientOverride.h