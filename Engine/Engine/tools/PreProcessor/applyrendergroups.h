ApplyRenderGroups.h