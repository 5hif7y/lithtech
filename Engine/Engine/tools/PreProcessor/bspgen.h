BspGen.h