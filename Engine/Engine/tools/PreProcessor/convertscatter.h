ConvertScatter.h