CreatePolyEdges.h