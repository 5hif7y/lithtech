gettextureflags.h