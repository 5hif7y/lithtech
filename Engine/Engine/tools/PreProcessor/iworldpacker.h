iworldpacker.h