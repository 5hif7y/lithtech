lmaabb.h