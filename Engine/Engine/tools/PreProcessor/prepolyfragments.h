prepolyfragments.h