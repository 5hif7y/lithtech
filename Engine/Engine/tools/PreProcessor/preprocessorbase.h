preprocessorbase.h