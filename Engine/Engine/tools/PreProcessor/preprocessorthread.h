preprocessorthread.h