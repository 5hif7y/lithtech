PreProcPackerImpl.h