splitpoly.h