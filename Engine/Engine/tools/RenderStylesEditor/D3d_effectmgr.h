d3d_effectmgr.h