d3dmeshrendobj_rigid.h