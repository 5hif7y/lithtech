d3d_vertstructs.h