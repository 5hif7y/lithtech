d3dmeshrendobj_skel.h