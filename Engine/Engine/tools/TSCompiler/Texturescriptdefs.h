texturescriptdefs.h