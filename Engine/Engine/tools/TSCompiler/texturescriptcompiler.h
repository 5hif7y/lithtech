texturescriptcompiler.h