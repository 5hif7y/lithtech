TextureScriptDefs.h