waveeditdlg.h