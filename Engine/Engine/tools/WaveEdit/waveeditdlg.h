WaveEditDlg.h