ltaview.h