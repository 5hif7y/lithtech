ltdirectmusiccontrolfile.h