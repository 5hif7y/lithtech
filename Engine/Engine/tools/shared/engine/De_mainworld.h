de_mainworld.h