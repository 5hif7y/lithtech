dtxmgr.h