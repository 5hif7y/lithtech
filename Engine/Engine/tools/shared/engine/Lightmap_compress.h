lightmap_compress.h