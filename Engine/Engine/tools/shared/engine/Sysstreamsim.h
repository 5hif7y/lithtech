sysstreamsim.h