worldtreehelper.h