bdefs.h