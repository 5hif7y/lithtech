concommand.h