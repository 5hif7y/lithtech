geomroutines.h