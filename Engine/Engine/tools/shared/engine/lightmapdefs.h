lightmapdefs.h