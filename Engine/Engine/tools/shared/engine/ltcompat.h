ltcompat.h