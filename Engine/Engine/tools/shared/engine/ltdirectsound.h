ltdirectsound.h