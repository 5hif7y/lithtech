exportsys.h