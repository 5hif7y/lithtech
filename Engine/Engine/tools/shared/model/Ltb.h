ltb.h