model_cleanup.h