ltamodel.h