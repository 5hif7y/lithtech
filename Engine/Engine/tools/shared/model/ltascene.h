ltascene.h