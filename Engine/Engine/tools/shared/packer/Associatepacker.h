associatepacker.h