IPackerImpl.h