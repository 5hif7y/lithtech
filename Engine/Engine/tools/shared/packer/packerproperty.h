packerproperty.h