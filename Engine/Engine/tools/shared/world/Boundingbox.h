boundingbox.h