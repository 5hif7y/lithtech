editray.h