ltasaveutils.h