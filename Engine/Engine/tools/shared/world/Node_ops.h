node_ops.h