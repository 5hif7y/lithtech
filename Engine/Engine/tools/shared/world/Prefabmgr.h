prefabmgr.h