s3tc_compress.h