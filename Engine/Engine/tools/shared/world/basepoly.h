basepoly.h