editbrush.h