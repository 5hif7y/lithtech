EditObjects.h