editplane.h