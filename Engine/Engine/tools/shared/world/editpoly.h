editpoly.h