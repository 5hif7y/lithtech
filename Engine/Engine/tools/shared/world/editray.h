EditRay.h