oldtypes.h