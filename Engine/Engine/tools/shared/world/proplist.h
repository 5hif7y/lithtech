proplist.h