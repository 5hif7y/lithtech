spritefile.h