texturedplane.h