worldnode.h