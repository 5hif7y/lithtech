basetypes_de.h