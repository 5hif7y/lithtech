dummypacker.h