packerregloc.h