DummyPacker.h