MessageOptions.h