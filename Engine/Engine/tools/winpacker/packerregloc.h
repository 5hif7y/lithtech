PackerRegLoc.h