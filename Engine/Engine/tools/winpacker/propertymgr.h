propertymgr.h