butemgr.h