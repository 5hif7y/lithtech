cryptmgr.h