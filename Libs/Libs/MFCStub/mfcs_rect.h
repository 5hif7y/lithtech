mfcs_rect.h