mfcs_string.h