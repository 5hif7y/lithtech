regmgr.h