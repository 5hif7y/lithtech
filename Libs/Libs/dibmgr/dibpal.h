dibpal.h