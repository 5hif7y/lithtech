dtxmgr_lib.h