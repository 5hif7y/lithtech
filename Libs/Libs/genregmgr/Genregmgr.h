genregmgr.h