basehash.h