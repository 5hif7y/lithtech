baselistcounter.h