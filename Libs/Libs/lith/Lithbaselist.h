lithbaselist.h