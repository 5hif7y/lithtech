lithchunkallocator.h