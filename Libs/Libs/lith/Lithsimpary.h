lithsimpary.h