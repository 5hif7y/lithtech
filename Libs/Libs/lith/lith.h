lith.h