lithsimparystat.h