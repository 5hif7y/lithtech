lithtmpl.h