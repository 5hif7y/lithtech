lithtypes.h