virtlist.h