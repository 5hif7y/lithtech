genhash.h