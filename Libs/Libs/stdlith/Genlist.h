genlist.h