goodlinklist.h