multilinklist.h