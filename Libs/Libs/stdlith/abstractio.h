abstractio.h