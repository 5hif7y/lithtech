dynarray.h