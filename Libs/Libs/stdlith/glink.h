glink.h