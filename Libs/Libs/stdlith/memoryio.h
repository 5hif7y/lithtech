memoryio.h