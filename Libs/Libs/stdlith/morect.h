morect.h