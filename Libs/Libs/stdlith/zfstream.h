zfstream.h