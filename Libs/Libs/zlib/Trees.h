trees.h