inffast.h