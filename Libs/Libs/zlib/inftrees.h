inftrees.h