clientres.h