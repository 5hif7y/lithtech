clientutil.h