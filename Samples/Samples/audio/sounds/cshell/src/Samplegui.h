samplegui.h