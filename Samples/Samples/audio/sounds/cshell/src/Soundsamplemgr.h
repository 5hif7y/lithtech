soundsamplemgr.h