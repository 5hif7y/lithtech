SoundSampleMgr.h