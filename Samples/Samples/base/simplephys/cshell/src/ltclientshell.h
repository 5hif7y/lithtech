ltclientshell.h