worldproperties.h