interfaceresmgr.h