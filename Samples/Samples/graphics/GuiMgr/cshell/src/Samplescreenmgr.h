samplescreenmgr.h