InterfaceResMgr.h