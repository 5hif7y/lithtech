layoutmgr.h