SampleScreenMgr.h