ltguitextitemctrl.h