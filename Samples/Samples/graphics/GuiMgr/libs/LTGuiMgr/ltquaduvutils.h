ltquaduvutils.h