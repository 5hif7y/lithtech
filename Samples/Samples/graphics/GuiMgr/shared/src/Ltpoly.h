ltpoly.h