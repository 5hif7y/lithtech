serverres.h