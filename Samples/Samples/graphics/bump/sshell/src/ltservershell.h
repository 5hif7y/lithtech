ltservershell.h