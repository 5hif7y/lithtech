dynamicmesh.h