clienthelper.h