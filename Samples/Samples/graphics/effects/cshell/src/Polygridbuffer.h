polygridbuffer.h