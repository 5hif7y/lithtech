sfxmgr.h