SFXMgr.h