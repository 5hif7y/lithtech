sharedfxstructs.h