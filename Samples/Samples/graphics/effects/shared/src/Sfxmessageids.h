sfxmessageids.h