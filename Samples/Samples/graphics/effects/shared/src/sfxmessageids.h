SFXMessageIDs.h