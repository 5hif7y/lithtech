gamebase.h