polygridmodifier.h