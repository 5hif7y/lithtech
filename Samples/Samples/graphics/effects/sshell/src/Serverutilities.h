serverutilities.h