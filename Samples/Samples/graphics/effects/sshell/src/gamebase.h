GameBase.h