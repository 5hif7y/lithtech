gamelight.h