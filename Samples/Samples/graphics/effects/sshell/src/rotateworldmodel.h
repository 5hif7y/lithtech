rotateworldmodel.h