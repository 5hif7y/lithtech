BackgroundMgr.h