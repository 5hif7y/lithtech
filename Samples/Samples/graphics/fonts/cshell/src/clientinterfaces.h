clientinterfaces.h