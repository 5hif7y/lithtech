serverinterfaces.h