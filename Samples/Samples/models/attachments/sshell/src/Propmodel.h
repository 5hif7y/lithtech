propmodel.h