playersrvr.h