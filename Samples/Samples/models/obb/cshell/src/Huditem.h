huditem.h