backgroundmgr.h