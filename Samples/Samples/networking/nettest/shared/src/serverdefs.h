serverdefs.h