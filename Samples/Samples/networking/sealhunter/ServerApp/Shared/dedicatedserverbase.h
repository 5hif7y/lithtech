dedicatedserverbase.h