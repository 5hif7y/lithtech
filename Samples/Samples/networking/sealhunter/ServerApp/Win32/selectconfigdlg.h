selectconfigdlg.h