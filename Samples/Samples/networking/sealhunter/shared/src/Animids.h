animids.h