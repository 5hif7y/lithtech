scoredefs.h