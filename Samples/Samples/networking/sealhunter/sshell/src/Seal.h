seal.h