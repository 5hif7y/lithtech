transworldmodel.h