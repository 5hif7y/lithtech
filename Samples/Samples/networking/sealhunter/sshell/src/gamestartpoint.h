gamestartpoint.h