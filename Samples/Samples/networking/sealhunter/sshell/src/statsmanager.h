statsmanager.h